options:
  parameters:
    author: p501_fft_example
    description: 'The B210 receives the OFDM frames of the P501 (or of ofdm_b210_frame_tx.grc) at 850 MHz, 3.84 MS/s and decodes them with separate blocks: S&C metric, frame detector, carrier corrections, FFT, channel estimate, equalizer, slicer, error counter; one plot tab per stage.'
    generate_options: qt_gui
    id: ofdm_b210_frame_rx
    output_language: python
    title: 'B210 receiver: OFDM frames (Schmidl-Cox sync, 16-QAM data), block by block'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3840000'
    comment: '3.84 MS/s: the sample rate of the P501 and of the OFDM frames; N = 64 subcarriers of 60 kHz'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
    comment: 'carrier: the same as the transmitter''s (the P501 notebook P501_OFDM_Live or ofdm_b210_frame_tx.grc); check the rules where you are before transmitting'
  states: {}
- name: capture_file
  id: variable
  parameters:
    value: '"ofdm_b210_capture.c64"'
    comment: a recording of the B210 samples (complex float, 3.84 MS/s) for the File Source (disabled by default) instead of the B210
  states: {}
- name: guard_level
  id: variable
  parameters:
    value: '0.1'
    comment: 'energy guard: a window counts only if its energy is at least this fraction of the long-term average (0.1 = -10 dB). A constant, a DC offset or noise that is not much weaker than the signal looks like a periodic signal to the S&C metric (M reaches 1 in the idle slot) whatever its level; the FPGA has the same guard as an absolute level (EMIN)'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    num_tabs: '6'
    label0: 1 Received signal
    label1: 2 Frame detection (Schmidl-Cox)
    label2: 3 Frame and carrier correction
    label3: 4 FFT
    label4: 5 Channel estimate
    label5: 6 Equalizer and decisions
    gui_hint: 2,0,1,6
    comment: one tab per stage of the receiver
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: raise it until the received spectrum is clearly above the noise and the constellation is clean; lower it if the samples clip
    gui_hint: 0,0,1,3
    label: B210 RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: 'a frame is found when M = |S|^2 / (Ea Eb) reaches this value (the P501 FPGA uses 0.65): lower finds weaker frames and gives more false detections, which the T1/T2 check throws away'
    gui_hint: 0,3,1,3
    label: S&C detection threshold (metric M)
    start: '0.3'
    step: '0.01'
    stop: '0.95'
    value: '0.65'
  states: {}
- name: decode_n
  id: variable_qtgui_range
  parameters:
    comment: 'the transmitter sends the same frame 1000 times per second: the Python blocks of this flowgraph cannot decode all of them in real time, so only 1 in N is passed on (8: 125 frames per second, 132 thousand symbols per second)'
    gui_hint: 1,0,1,3
    label: decode 1 frame in N
    rangeType: int
    start: '1'
    step: '1'
    stop: '40'
    value: '8'
  states: {}
- name: smooth
  id: variable_qtgui_range
  parameters:
    comment: 'the common gain and the slope found from the 4 pilots are averaged over this many symbols (centred): less noise, slower tracking'
    gui_hint: 1,3,1,3
    label: pilot smoothing (symbols)
    rangeType: int
    start: '1'
    step: '2'
    stop: '9'
    value: '5'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: the B210 receiver (RX2 port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: file_source_0
  id: blocks_file_source
  parameters:
    file: capture_file
    type: complex
    repeat: 'True'
    comment: 'disabled: enable it (and the Throttle) and disable the B210 to replay a recording'
  states: {state: disabled}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
    comment: the file is read at the sample rate of the B210
  states: {state: disabled}
- name: rx_in
  id: blocks_copy
  parameters:
    type: complex
    comment: 'the one entry point of the receiver: the B210 (enabled) or the recording (enable the File Source and the Throttle, disable the B210)'
  states: {}
- name: dc_iir
  id: single_pole_iir_filter_xx
  parameters:
    type: complex
    alpha: '1e-4'
    comment: 'the DC offset (the local oscillator leakage of the B210, the spike at 0 Hz of the spectrum) as a very slow low-pass: the time constant is 10000 samples'
  states: {}
- name: dc_sub
  id: blocks_sub_xx
  parameters:
    type: complex
    comment: x minus its DC. Without this the idle slot (80 samples with only noise and the DC) looks like a periodic signal to the S&C metric and fires the detector one symbol before the real S&C symbol
  states: {}
- name: x_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|x| after the DC removal: the frames (3760 active samples of 3840) with the idle slot between them'
  states: {}
- name: freq_sink_rx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: tabs@0:0,0,1,1
    label1: B210 RX2
    legend: 'False'
    name: '"received spectrum (raw): 28 subcarriers of 60 kHz = 1.7 MHz wide; the spike at 0 is the DC / LO leakage"'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@0:1,0,1,1
    label1: '|x|'
    legend: 'False'
    name: '"received signal |x| (two frames of 3840 samples = 1 ms each)"'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymin: '0'
  states: {}
- name: sc_delay
  id: blocks_delay
  parameters:
    type: complex
    delay: '32'
    comment: 'x[n-32]: the S&C symbol (even subcarriers only) is two identical halves of 32 samples'
  states: {}
- name: sc_conj
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: sc_mult
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: x[n] conj(x[n-32])
  states: {}
- name: sc_avg
  id: blocks_moving_average_xx
  parameters:
    type: complex
    length: '32'
    scale: '1'
    max_iter: '4000'
    comment: 'S[n] = sum of 32 products: |S| is large when the last 64 samples are two equal halves, its angle is 32 x the carrier offset per sample'
  states: {}
- name: sc_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: '|S|^2'
  states: {}
- name: en_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: '|x|^2'
  states: {}
- name: en_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '32'
    scale: '1'
    max_iter: '4000'
    comment: 'Eb: the energy of the newer 32 samples'
  states: {}
- name: en_delay
  id: blocks_delay
  parameters:
    type: float
    delay: '32'
    comment: 'Ea: the energy of the older 32 samples'
  states: {}
- name: en_mult
  id: blocks_multiply_xx
  parameters:
    type: float
    comment: 'Ea Eb: the normalisation. With |S|^2 / Eb^2 alone a strong frame that ends in noise would fire the detector (the P501 FPGA has a guard for this); Ea Eb keeps M <= 1'
  states: {}
- name: guard_avg
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: '2.4e-4'
    comment: the long-term average power P of the signal (time constant 4096 samples, about 1 frame)
  states: {}
- name: guard_sq
  id: blocks_multiply_xx
  parameters:
    type: float
    comment: P^2
  states: {}
- name: guard_k
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: (guard_level * 32) ** 2
    comment: '(guard_level 32 P)^2: the square of the smallest window energy that may count'
  states: {}
- name: guard_add
  id: blocks_add_xx
  parameters:
    type: float
    comment: 'Ea Eb + guard: in the idle slot Ea Eb is far below the guard, so M = |S|^2 / (Ea Eb + guard) is small there whatever the content of the slot; in the frame Ea Eb is far above it and M is unchanged'
  states: {}
- name: en_eps
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1e-12'
    comment: avoids a division by zero
  states: {}
- name: sc_div
  id: blocks_divide_xx
  parameters:
    type: float
    comment: 'M[n] = |S|^2 / (Ea Eb + guard): about 1 (a plateau of 17 samples) when the last 64 samples are the S&C symbol, small everywhere else'
  states: {}
- name: thr_src
  id: analog_const_source_x
  parameters:
    type: float
    const: threshold
    comment: the detection threshold, drawn with M
  states: {}
- name: time_sink_m
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@1:0,0,1,1
    label1: M
    label2: threshold
    legend: 'False'
    name: '"Schmidl-Cox metric M and the threshold (two frames)"'
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: M
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: det
  id: epy_block
  parameters:
    threshold: threshold
    back: '6'
    skip: decode_n - 1
    _source_code: |
      """Schmidl-and-Cox frame detector. Inputs: the received samples x, the S&C metric M = |S|^2 / (Ea Eb) and the sum S of 32 products x[n] conj(x[n-32]) (all three aligned: the window ends at sample n).
      When M reaches `threshold` the next 72 windows are collected, the plateau (the windows with M >= 29/32 of the largest) is found and the middle of it gives the start of the S&C symbol: s0 = (window start) + (first + last + 1) // 2 - 8.
      Only 1 frame in `skip + 1` is passed on (the transmitter repeats the same frame every 3840 samples; the python blocks behind could not follow 1000 frames per second in real time): after a frame the search starts again `skip` frames later.
      The output is the frame as 3760 samples (47 symbols of 80: S&C, T1, T2 and 44 data symbols; the idle slot is dropped) starting `back` samples before s0 (the FFT windows then start inside the cyclic prefix: a timing error
      of up to `back` samples is harmless). Two tags are put on the first sample: `cfo` (the coarse carrier offset in rad/sample = arg(sum of S over the plateau) / 32) and `gain` (1 / rms of the first 240 samples)."""
      import numpy as np
      import pmt
      from gnuradio import gr

      FRAME = 3760        # 47 symbols of 80 samples


      class blk(gr.basic_block):
          def __init__(self, threshold=0.65, back=6, skip=3):
              gr.basic_block.__init__(self, name="S&C frame detector", in_sig=[np.complex64, np.float32, np.complex64], out_sig=[np.complex64])
              self.threshold, self.back, self.skip = threshold, back, skip
              self.x = np.zeros(0, np.complex64); self.M = np.zeros(0, np.float32); self.S = np.zeros(0, np.complex64)
              self.base = 0                 # absolute index of x[0]
              self.scan = 0                 # absolute index where the search for the next frame goes on
              self.total = 0                # absolute index of the next input sample
              self.skip_until = 0           # absolute index: input before it is dropped (the frames that are skipped)
              self.queue = []               # (frame, cfo, gain)
              self.cur = None; self.pos = 0
              self.frames = 0

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def _trim(self, keep_from):
              k = int(min(max(keep_from, 0), len(self.x)))
              if k:
                  self.x, self.M, self.S = self.x[k:], self.M[k:], self.S[k:]; self.base += k

          def _search(self):
              while True:
                  lo = max(self.scan - self.base, 0)
                  idx = np.nonzero(self.M[lo:] >= self.threshold)[0]
                  if len(idx) == 0:
                      self.scan = self.base + len(self.M); self._trim(len(self.M) - 400); return
                  m0 = lo + int(idx[0])                         # the window ends here
                  if m0 + 72 > len(self.M): self._trim(m0 - 120); return
                  seg = self.M[m0:m0 + 72]; pk = float(seg.max())
                  pl = np.nonzero(seg >= pk * 29 / 32)[0]; first, last = int(pl[0]), int(pl[-1])
                  n0 = m0 - 63                                  # the window starts here
                  s0 = n0 + ((first + last + 1) >> 1) - 8
                  start = s0 - self.back; end = start + FRAME
                  if start < 0:
                      self.scan = self.base + m0 + 72; continue
                  if end > len(self.x): self._trim(m0 - 120); return
                  cfo = float(np.angle(np.sum(self.S[m0 + first:m0 + last + 1])) / 32.0)
                  fr = self.x[start:end].copy(); rms = float(np.sqrt(np.mean(np.abs(fr[:240]) ** 2))) + 1e-20
                  self.queue.append((fr, cfo, 1.0 / rms)); self.frames += 1
                  self.scan = self.base + end; self._trim(end - 120)
                  self.skip_until = max(self.scan, self.scan + 86 + int(self.skip) * 3840 - 600)       # the next frame's S&C symbol is 86 samples after the end of this one; start 600 samples before the frame to be used

          def general_work(self, input_items, output_items):
              out = output_items[0]; produced = 0
              n = min(len(input_items[0]), len(input_items[1]), len(input_items[2]), 16384)
              if n > 0 and len(self.queue) < 4:
                  if self.total + n <= self.skip_until:                                   # inside the frames that are skipped: nothing is kept
                      self.x = self.x[:0]; self.M = self.M[:0]; self.S = self.S[:0]; self.base = self.total + n; self.scan = self.base
                  else:
                      if len(self.x) == 0 and self.total < self.skip_until:                 # the chunk that ends the skipping: keep only its part after skip_until
                          k = self.skip_until - self.total
                          self.x = input_items[0][k:n].copy(); self.M = input_items[1][k:n].copy(); self.S = input_items[2][k:n].copy(); self.base = self.total + k; self.scan = self.base
                      else:
                          self.x = np.concatenate([self.x, input_items[0][:n]]); self.M = np.concatenate([self.M, input_items[1][:n]]); self.S = np.concatenate([self.S, input_items[2][:n]])
                      self._search()
                  self.total += n; self.consume_each(n)
              while produced < len(out):
                  if self.cur is None:
                      if not self.queue: break
                      self.cur, cfo, gain = self.queue.pop(0); self.pos = 0
                      off = self.nitems_written(0) + produced
                      self.add_item_tag(0, off, pmt.intern("cfo"), pmt.from_double(cfo)); self.add_item_tag(0, off, pmt.intern("gain"), pmt.from_double(gain))
                  k = min(len(out) - produced, len(self.cur) - self.pos)
                  out[produced:produced + k] = self.cur[self.pos:self.pos + k]; self.pos += k; produced += k
                  if self.pos == len(self.cur): self.cur = None
              return produced
    comment: 'S&C frame detector: the first window with M >= threshold starts a search over 72 windows; the middle of the plateau (the windows with M >= 29/32 of the largest) gives the start of the S&C symbol; the output is the frame of 47 symbols (3760 samples) with tags cfo (coarse carrier offset from arg S) and gain'
  states: {}
- name: coarse
  id: epy_block
  parameters:
    back: '6'
    _source_code: |
      """Coarse carrier correction and gain: every frame (3760 samples) is multiplied by gain * exp(-j cfo (i - back)), `cfo` and `gain` being the tags of the frame detector. The S&C estimate is unambiguous within +-60 kHz
      (the phase over the 32-sample delay stays within +-pi); what is left (a few hundred Hz) is measured from the two training symbols in the next block."""
      import numpy as np
      import pmt
      from gnuradio import gr

      FRAME = 3760


      class blk(gr.sync_block):
          def __init__(self, back=6):
              gr.sync_block.__init__(self, name="Coarse CFO correction", in_sig=[np.complex64], out_sig=[np.complex64])
              self.back = back
              self.i = (np.arange(FRAME) - back).astype(np.float32)
              self.set_output_multiple(FRAME)

          def work(self, input_items, output_items):
              x, y = input_items[0], output_items[0]
              nf = len(y) // FRAME
              i = self.i
              for f in range(nf):
                  a = f * FRAME; cfo, gain = 0.0, 1.0
                  for t in self.get_tags_in_window(0, a, a + 1):
                      k = pmt.symbol_to_string(t.key)
                      if k == "cfo": cfo = pmt.to_double(t.value)
                      elif k == "gain": gain = pmt.to_double(t.value)
                  ph = np.empty(FRAME, np.complex64); ang = np.float32(cfo) * i; ph.real = np.cos(ang); ph.imag = -np.sin(ang)
                  y[a:a + FRAME] = x[a:a + FRAME] * ph * np.float32(gain)
              return nf * FRAME
    comment: 'coarse carrier correction: x exp(-j cfo n) from the tag, and the gain (unit rms)'
  states: {}
- name: fine
  id: epy_block
  parameters:
    back: '6'
    check: 'True'
    _source_code: |
      """Fine carrier correction and the check of the frame. The two training symbols T1 and T2 are the same 64 samples, 80 samples apart: P = sum T2 conj(T1), the remaining carrier offset is arg(P) / 80 rad/sample.
      The frame is accepted when the two symbols really repeat: 2 |P|^2 >= E1 E2 (the normalised correlation is above 0.71); a false detection in noise is replaced by zeros (the later blocks skip it).
      Outputs: 1: the total carrier offset (coarse + fine) in Hz, 2: 1.0 for an accepted frame, 0.0 for a rejected one (one value per sample)."""
      import numpy as np
      import pmt
      from gnuradio import gr

      FRAME = 3760; FS = 3.84e6


      class blk(gr.sync_block):
          def __init__(self, back=6, check=True):
              gr.sync_block.__init__(self, name="Fine CFO correction and T1/T2 check", in_sig=[np.complex64], out_sig=[np.complex64, np.float32, np.float32])
              self.back, self.check = back, check
              self.i = (np.arange(FRAME) - back).astype(np.float32)
              self.set_output_multiple(FRAME)
              self.accepted = 0; self.rejected = 0

          def work(self, input_items, output_items):
              x, y, hz, okf = input_items[0], output_items[0], output_items[1], output_items[2]
              nf = len(y) // FRAME
              i = self.i
              for f in range(nf):
                  a = f * FRAME; cfo = 0.0
                  for t in self.get_tags_in_window(0, a, a + 1):
                      if pmt.symbol_to_string(t.key) == "cfo": cfo = pmt.to_double(t.value)
                  fr = x[a:a + FRAME]
                  T1, T2 = fr[96:160], fr[176:240]                     # the FFT windows of symbols 1 and 2: 80 s + 16
                  P = np.sum(T2 * np.conj(T1)); E1 = float(np.sum(np.abs(T1) ** 2)); E2 = float(np.sum(np.abs(T2) ** 2))
                  ok = (2 * abs(P) ** 2 >= E1 * E2) or not self.check
                  wf = float(np.angle(P)) / 80.0
                  if ok:
                      ph = np.empty(FRAME, np.complex64); ang = np.float32(wf) * i; ph.real = np.cos(ang); ph.imag = -np.sin(ang)
                      y[a:a + FRAME] = fr * ph; self.accepted += 1
                  else:
                      y[a:a + FRAME] = 0; self.rejected += 1
                  hz[a:a + FRAME] = (cfo + wf) * FS / (2 * np.pi); okf[a:a + FRAME] = 1.0 if ok else 0.0
              return nf * FRAME
    comment: 'the two training symbols T1 and T2 are the same 64 samples 80 apart: arg(sum T2 conj T1) / 80 is the carrier offset that is left; they must also repeat (|P|^2 >= E1 E2 / 2), or the frame is a false detection and is replaced by zeros'
  states: {}
- name: frame_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|frame|'
  states: {}
- name: time_sink_frame
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@2:0,0,1,3
    label1: '|frame|'
    legend: 'False'
    name: '"the frame after the carrier corrections: S&C | T1 | T2 | 44 data symbols (47 x 80 samples)"'
    size: '3760'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '0'
  states: {}
- name: number_cfo
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@2:1,0,1,1
    label1: carrier offset
    min: '0'
    name: '"carrier offset (Hz): coarse + fine"'
    type: float
    unit1: Hz
    update_time: '0.25'
  states: {}
- name: number_ok
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@2:1,1,1,1
    label1: accepted
    min: '0'
    name: '"frame accepted by the T1/T2 check (1) or thrown away (0)"'
    type: float
    update_time: '0.25'
  states: {}
- name: keep64
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: '64'
    n: '80'
    offset: '16'
    comment: 'the cyclic prefix is removed: of every symbol of 80 samples the 64 after the first 16 are kept (the frame starts 6 samples early, so the FFT window starts inside the prefix: a timing error of up to 6 samples is only a phase slope that the channel estimate removes)'
  states: {}
- name: s2v64
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: fft64
  id: fft_vxx
  parameters:
    type: complex
    fft_size: '64'
    forward: 'True'
    window: '[]'
    shift: 'True'
    comment: '64-point FFT; shift: the bin k + 32 holds the subcarrier k (the carrier k = 0 is in the middle)'
  states: {}
- name: fft_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '[1.0 / 8.0] * 64'
    vlen: '64'
    comment: '1 / sqrt(64): a subcarrier of unit power gives a bin of unit power'
  states: {}
- name: fft_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: '64'
  states: {}
- name: fft_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '64'
    scale: 1.0 / 64
    max_iter: '4000'
    vlen: '64'
    comment: 'the mean of |FFT| of 64 symbols: the occupied band of 28 subcarriers (k = -14 .. +14)'
  states: {}
- name: vec_fft
  id: qtgui_vector_sink_f
  parameters:
    name: '"|FFT| of the OFDM symbols (mean of 64 symbols): subcarrier k = bin - 32"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"|X[k]|"'
    ymin: '0'
    ymax: '3'
    gui_hint: tabs@3:0,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: v2s64
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: keep29
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: '29'
    n: '64'
    offset: '18'
    comment: the used subcarriers k = -14 .. +14 (29 bins, including the unused DC) of the 64
  states: {}
- name: const_raw
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@3:1,0,1,1
    label1: symbols
    legend: 'False'
    name: '"after the FFT, before the equalizer (used subcarriers: the channel and the carrier rotate and scale the points)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: s2v29
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '29'
  states: {}
- name: est
  id: epy_block
  parameters:
    _source_code: |
      """Channel estimate. Input: the 47 symbols of a frame as vectors of 29 values (subcarriers k = -14 .. +14, the middle one is the unused DC). Symbol 0 is the S&C symbol (not used here), symbols 1 and 2 are the two training
      symbols T1 and T2 (the same known QPSK value TRAIN[k] of unit power on all 28 used subcarriers): H[k] = (T1[k] + T2[k]) / 2 * conj(TRAIN[k]). Outputs: 0: the 44 data symbols (29 values each), 1: H (29 values, one per frame; 0 at DC)."""
      import numpy as np
      from gnuradio import gr

      TRAIN_SIGNS = [(1, -1), (-1, -1), (1, -1), (1, -1), (-1, 1), (-1, -1), (1, -1), (1, 1), (1, -1), (-1, 1), (1, 1), (-1, -1), (1, -1), (1, 1), (1, -1), (-1, 1), (1, 1), (-1, -1), (1, -1), (1, -1), (1, 1), (1, 1), (1, 1), (1, -1), (-1, 1), (-1, -1), (-1, 1), (-1, -1)]
      TRAIN = np.array([(a + 1j * b) / np.sqrt(2) for a, b in TRAIN_SIGNS])
      USED_IDX = np.array([i for i in range(29) if i != 14])           # index = k + 14
      NSYM, NDATA = 47, 44


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="Channel estimator", in_sig=[(np.complex64, 29)], out_sig=[(np.complex64, 29), (np.complex64, 29)])
              self.set_output_multiple(NDATA)

          def forecast(self, noutput_items, ninputs):
              return [NSYM * max(1, noutput_items // NDATA)]

          def general_work(self, input_items, output_items):
              x, d, h = input_items[0], output_items[0], output_items[1]
              nf = min(len(x) // NSYM, len(d) // NDATA, len(h))
              for f in range(nf):
                  fr = x[f * NSYM:(f + 1) * NSYM]
                  H = np.zeros(29, np.complex64); H[USED_IDX] = 0.5 * (fr[1][USED_IDX] + fr[2][USED_IDX]) * np.conj(TRAIN)
                  h[f] = H; d[f * NDATA:(f + 1) * NDATA] = fr[3:]
              self.consume_each(nf * NSYM)
              self.produce(0, nf * NDATA); self.produce(1, nf)
              return gr.WORK_CALLED_PRODUCE
    comment: 'channel estimator: H[k] = (T1[k] + T2[k]) / 2 conj(TRAIN[k]) from the two training symbols of the frame; passes the 44 data symbols on'
  states: {}
- name: h_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: '29'
  states: {}
- name: h_arg
  id: blocks_complex_to_arg
  parameters:
    vlen: '29'
  states: {}
- name: vec_hmag
  id: qtgui_vector_sink_f
  parameters:
    name: '"channel |H[k]| (k = 0, the DC, is not used)"'
    vlen: '29'
    x_start: '-14'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"|H|"'
    ymin: '0'
    ymax: '2'
    autoscale: 'True'
    gui_hint: tabs@4:0,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: vec_harg
  id: qtgui_vector_sink_f
  parameters:
    name: '"channel phase arg H[k] (rad): a straight line = a delay (the timing offset and the early FFT window)"'
    vlen: '29'
    x_start: '-14'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"rad"'
    ymin: '-3.2'
    ymax: '3.2'
    gui_hint: tabs@4:1,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: eq
  id: epy_block
  parameters:
    smooth: smooth
    slope: 'True'
    _source_code: |
      """One-tap equalizer per subcarrier and pilot tracking. Inputs: 0: the 44 data symbols of a frame (29 values each), 1: the channel estimate H of the frame. Per symbol l:
        1. zero forcing: Z[k] = Y[k] / H[k]  (the data subcarriers and the 4 pilots k = -11, -4, 4, 11)
        2. the pilots should be PIL_V * POL[l] (QPSK, the polarity follows the PRBS-7 of IEEE 802.11): the phase of Z[pilot] conj(reference) against k is a straight line: its slope is a timing drift, removed from all subcarriers;
           the mean of the pilots is the common complex gain g of the symbol (common phase error and a gain change)
        3. slope and g are averaged over `smooth` symbols (a moving average centred on the symbol, shorter at the ends of the frame), the data are divided by g.
      Outputs: 0: the 24 corrected data values per symbol, 1: arg(g) of the symbol in rad (the common phase error), 2: |g|. A frame without a channel estimate (H = 0, a rejected frame) gives zeros."""
      import numpy as np
      from gnuradio import gr

      NDATA_SYM = 44
      KS = np.arange(-14, 15)
      PIL = np.array([-11, -4, 4, 11]); DATA = np.array([k for k in range(-14, 15) if k != 0 and k not in (-11, -4, 4, 11)])
      PIL_IDX, DATA_IDX = PIL + 14, DATA + 14
      PIL_V = np.array([1 + 1j, 1 - 1j, -1 + 1j, -1 - 1j]) / np.sqrt(2)
      POL = np.array([-1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, -1], float)


      REF = PIL_V[None, :] * POL[:, None]                  # the pilot values of every symbol (44 x 4)


      def smoothing_matrix(n, L=NDATA_SYM):
          """centred moving average of n symbols, shorter at the ends of the frame, as a matrix (L x L)"""
          if n <= 1: return np.eye(L)
          w = np.ones(n); M = np.zeros((L, L))
          for j in range(L): M[:, j] = np.convolve(np.eye(L)[j], w, "same")
          return M / M.sum(axis=1, keepdims=True)


      class blk(gr.basic_block):
          def __init__(self, smooth=5, slope=True):
              gr.basic_block.__init__(self, name="Equalizer and pilot tracking", in_sig=[(np.complex64, 29), (np.complex64, 29)], out_sig=[(np.complex64, 24), np.float32, np.float32])
              self.slope = slope
              self.smooth = smooth
              self.set_output_multiple(NDATA_SYM)

          @property
          def smooth(self):
              return self._smooth

          @smooth.setter
          def smooth(self, v):
              self._smooth = int(v); self.SM = smoothing_matrix(self._smooth)

          def forecast(self, noutput_items, ninputs):
              k = max(1, noutput_items // NDATA_SYM)
              return [NDATA_SYM * k, k]

          def general_work(self, input_items, output_items):
              y, h = input_items
              z, ph, mag = output_items
              nf = min(len(y) // NDATA_SYM, len(h), len(z) // NDATA_SYM, len(ph) // NDATA_SYM, len(mag) // NDATA_SYM)
              for f in range(nf):
                  H = h[f].astype(complex); Y = y[f * NDATA_SYM:(f + 1) * NDATA_SYM].astype(complex)
                  o = slice(f * NDATA_SYM, (f + 1) * NDATA_SYM)
                  if np.all(np.abs(H) < 1e-12):
                      z[o] = 0; ph[o] = 0; mag[o] = 0; continue
                  zd = Y[:, DATA_IDX] / H[DATA_IDX]; zp = Y[:, PIL_IDX] / H[PIL_IDX]
                  sl = np.zeros(NDATA_SYM)
                  if self.slope:
                      phs = np.unwrap(np.angle(zp * np.conj(REF)), axis=1); sl = (phs * PIL[None, :]).sum(axis=1) / np.sum(PIL ** 2)
                      zp = zp * np.exp(-1j * sl[:, None] * PIL[None, :])
                  g = (zp * np.conj(REF)).sum(axis=1) / len(PIL)
                  g = self.SM @ g; sl = self.SM @ sl
                  if self.slope: zd = zd * np.exp(-1j * sl[:, None] * DATA[None, :])
                  z[o] = (zd / g[:, None]).astype(np.complex64); ph[o] = np.angle(g); mag[o] = np.abs(g)
              self.consume(0, nf * NDATA_SYM); self.consume(1, nf)
              for i in range(3): self.produce(i, nf * NDATA_SYM)
              return gr.WORK_CALLED_PRODUCE
    comment: 'one tap per subcarrier (Y / H) and the pilots: the 4 QPSK pilots (-11, -4, 4, 11, polarity PRBS-7 of IEEE 802.11) give a phase slope over k (timing drift) and the common complex gain g (common phase error and gain) of every symbol; the data are divided by them'
  states: {}
- name: v2s24
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '24'
  states: {}
- name: const_eq
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@5:0,0,2,1
    label1: symbols
    legend: 'False'
    name: '"data symbols after the equalizer (24 subcarriers x 44 symbols per frame)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: time_sink_pilot
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@5:0,1,1,2
    label1: arg g
    label2: '|g|'
    legend: 'False'
    name: '"pilot tracking per symbol: arg g (rad, the common phase error) and |g| (gain)"'
    nconnections: '2'
    size: '440'
    srate: samp_rate / 80
    type: float
    update_time: '0.1'
    ylabel: ''
    ymax: '3.5'
    ymin: '-3.5'
  states: {}
- name: slicer
  id: epy_block
  parameters:
    _source_code: |
      """16-QAM slicer: the nearest of the levels -3 -1 +1 +3 (/ sqrt 10) on each axis, as the Gray code of the transmitter (levels -3 -1 +1 +3 = 00 01 11 10): the output byte is 4 * (I code) + (Q code), 0 .. 15.
      A value of exactly 0 (a rejected frame) gives 255."""
      import numpy as np
      from gnuradio import gr

      T = np.float32(2 / np.sqrt(10))              # decision thresholds -2, 0, +2 (/ sqrt 10)
      GRAY = np.array([0, 1, 3, 2], np.uint8)       # the level index 0 1 2 3 (-3 -1 +1 +3) -> the Gray code


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="16-QAM slicer", in_sig=[np.complex64], out_sig=[np.uint8])

          def work(self, input_items, output_items):
              z, o = input_items[0], output_items[0]
              re, im = z.real, z.imag
              ii = (re > -T).astype(np.uint8) + (re > 0) + (re > T); qq = (im > -T).astype(np.uint8) + (im > 0) + (im > T)
              o[:] = GRAY[ii] * 4 + GRAY[qq]
              o[z == 0] = 255
              return len(o)
    comment: '16-QAM slicer: nearest level on each axis, the Gray code of the transmitter, one byte (0 .. 15) per symbol'
  states: {}
- name: counter
  id: epy_block
  parameters:
    _source_code: |
      """Symbol error counter. The payload of every frame is the PRBS-15 (x^15 + x^14 + 1, seed 0x7FFF, 4 bits per 16-QAM symbol, the first bit pair = I) restarted in every frame: 44 symbols x 24 subcarriers = 1056 values.
      Every frame of 1056 slicer bytes is compared with it (a rejected frame, bytes of 255, is skipped). Outputs (one value per input byte): 0: symbol error rate since the start, 1: symbol errors, 2: frames decoded."""
      import numpy as np
      from gnuradio import gr

      NPAY = 1056


      def prbs15_symbols(n):
          s, bits = 0x7FFF, []
          for _ in range(4 * n):
              bits.append((s >> 14) & 1); s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)
          b = np.array(bits, int).reshape(n, 4)
          return (b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]).astype(np.uint8)


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="Symbol error counter", in_sig=[np.uint8], out_sig=[np.float32, np.float32, np.float32])
              self.ref = prbs15_symbols(NPAY)
              self.sym = 0; self.err = 0; self.frames = 0
              self.set_output_multiple(NPAY)

          def work(self, input_items, output_items):
              x = input_items[0]; nf = len(output_items[0]) // NPAY
              for f in range(nf):
                  fr = x[f * NPAY:(f + 1) * NPAY]
                  if not np.any(fr == 255):
                      self.err += int(np.count_nonzero(fr != self.ref)); self.sym += NPAY; self.frames += 1
                  sl = slice(f * NPAY, (f + 1) * NPAY)
                  output_items[0][sl] = self.err / self.sym if self.sym else 0.0; output_items[1][sl] = self.err; output_items[2][sl] = self.frames
              return nf * NPAY
    comment: 'compares every frame with the PRBS-15 payload that the transmitter sends: symbol errors since the start, symbol error rate, frames decoded'
  states: {}
- name: number_ser
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:1,1,1,1
    label1: SER
    min: '0'
    name: '"symbol error rate (since the start)"'
    type: float
    update_time: '0.25'
  states: {}
- name: number_err
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:1,2,1,1
    label1: errors
    min: '0'
    name: '"symbol errors"'
    type: float
    update_time: '0.25'
  states: {}
- name: number_frames
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:1,3,1,1
    label1: frames
    min: '0'
    name: '"frames decoded"'
    type: float
    update_time: '0.25'
  states: {}

connections:
- [uhd_usrp_source_0, '0', rx_in, '0']
- [file_source_0, '0', throttle_0, '0']
- [throttle_0, '0', rx_in, '0']
- [rx_in, '0', dc_iir, '0']
- [rx_in, '0', dc_sub, '0']
- [dc_iir, '0', dc_sub, '1']
- [dc_sub, '0', x_mag, '0']
- [rx_in, '0', freq_sink_rx, '0']
- [x_mag, '0', time_sink_rx, '0']
- [dc_sub, '0', sc_delay, '0']
- [sc_delay, '0', sc_conj, '0']
- [dc_sub, '0', sc_mult, '0']
- [sc_conj, '0', sc_mult, '1']
- [sc_mult, '0', sc_avg, '0']
- [sc_avg, '0', sc_mag2, '0']
- [dc_sub, '0', en_mag2, '0']
- [en_mag2, '0', en_avg, '0']
- [en_avg, '0', en_mult, '1']
- [en_avg, '0', en_delay, '0']
- [en_delay, '0', en_mult, '0']
- [en_mag2, '0', guard_avg, '0']
- [guard_avg, '0', guard_sq, '0']
- [guard_avg, '0', guard_sq, '1']
- [guard_sq, '0', guard_k, '0']
- [en_mult, '0', guard_add, '0']
- [guard_k, '0', guard_add, '1']
- [guard_add, '0', en_eps, '0']
- [sc_mag2, '0', sc_div, '0']
- [en_eps, '0', sc_div, '1']
- [sc_div, '0', time_sink_m, '0']
- [thr_src, '0', time_sink_m, '1']
- [dc_sub, '0', det, '0']
- [sc_div, '0', det, '1']
- [sc_avg, '0', det, '2']
- [det, '0', coarse, '0']
- [coarse, '0', fine, '0']
- [fine, '0', frame_mag, '0']
- [frame_mag, '0', time_sink_frame, '0']
- [fine, '1', number_cfo, '0']
- [fine, '2', number_ok, '0']
- [fine, '0', keep64, '0']
- [keep64, '0', s2v64, '0']
- [s2v64, '0', fft64, '0']
- [fft64, '0', fft_scale, '0']
- [fft_scale, '0', fft_mag, '0']
- [fft_mag, '0', fft_avg, '0']
- [fft_avg, '0', vec_fft, '0']
- [fft_scale, '0', v2s64, '0']
- [v2s64, '0', keep29, '0']
- [keep29, '0', const_raw, '0']
- [keep29, '0', s2v29, '0']
- [s2v29, '0', est, '0']
- [est, '1', h_mag, '0']
- [est, '1', h_arg, '0']
- [h_mag, '0', vec_hmag, '0']
- [h_arg, '0', vec_harg, '0']
- [est, '0', eq, '0']
- [est, '1', eq, '1']
- [eq, '0', v2s24, '0']
- [v2s24, '0', const_eq, '0']
- [eq, '1', time_sink_pilot, '0']
- [eq, '2', time_sink_pilot, '1']
- [v2s24, '0', slicer, '0']
- [slicer, '0', counter, '0']
- [counter, '0', number_ser, '0']
- [counter, '1', number_err, '0']
- [counter, '2', number_frames, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
