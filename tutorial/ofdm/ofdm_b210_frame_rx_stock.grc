options:
  parameters:
    author: p501_fft_example
    description: 'The B210 receives the OFDM frames of the P501 (or of ofdm_b210_frame_tx.grc) at 850 MHz, 3.84 MS/s and decodes them with the stock gr-digital OFDM blocks: Schmidl and Cox synchroniser, header/payload demux, FFT, channel estimator, frame equalizer, serializer, constellation decoder. One small Python block stands in for the packet header, one counts the errors.'
    generate_options: qt_gui
    id: ofdm_b210_frame_rx_stock
    output_language: python
    title: 'B210 receiver: OFDM frames with the stock GNU Radio OFDM blocks'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3840000'
    comment: '3.84 MS/s: the sample rate of the P501 and of the OFDM frames; N = 64 subcarriers of 60 kHz'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
    comment: 'carrier: the same as the transmitter''s (the P501 notebook P501_OFDM_Live or ofdm_b210_frame_tx.grc); check the rules where you are before transmitting'
  states: {}
- name: capture_file
  id: variable
  parameters:
    value: '"ofdm_b210_capture.c64"'
    comment: a recording of the B210 samples (complex float, 3.84 MS/s) for the File Source (disabled by default) instead of the B210
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
    comment: FFT length N
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '16'
    comment: cyclic prefix, in samples
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_length"'
    comment: the tag that carries the number of OFDM symbols of the payload through the receiver
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: ([-14, -13, -12, -10, -9, -8, -7, -6, -5, -3, -2, -1, 1, 2, 3, 5, 6, 7, 8, 9, 10, 12, 13, 14],)
    comment: the 24 data subcarriers (k = -14 .. +14 without 0 and without the pilots), in the order of the transmitter
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ([-11, -4, 4, 11],)
    comment: the 4 pilot subcarriers
  states: {}
- name: pilot_polarity
  id: variable
  parameters:
    value: '[-1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, -1]'
    comment: the sign of the pilots in every one of the 44 data symbols (PRBS-7 of IEEE 802.11)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: tuple(tuple(p * v for v in ((0.707106781187+0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j))) for p in pilot_polarity)
    comment: 'the pilot values of every data symbol: QPSK, times the polarity. The stock equalizer takes one list of 4 values per symbol and repeats the list when the frame is longer'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, (-1-1j), 0j, (-1+1j), 0j, (-1-1j), 0j, (-1-1j), 0j, (1+1j), 0j, (-1-1j), 0j, (-1-1j), 0j, 0j, 0j, (1+1j), 0j, (1+1j), 0j, (1-1j), 0j, (-1-1j), 0j, (-1+1j), 0j, (-1-1j), 0j, (-1+1j), 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j]'
    comment: 'the S&C symbol in the frequency domain (DC in the middle): QPSK on the even subcarriers only, zero on the odd ones, so the time signal is two identical halves'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, (0.707106781187-0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187+0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187+0.707106781187j), 0j, (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187+0.707106781187j), (0.707106781187+0.707106781187j), (0.707106781187+0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j]'
    comment: 'the training symbol T1 (and T2): QPSK on all 28 used subcarriers; the channel estimator divides what it receives by it'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_calcdist([((-3, -1, 3, 1)[i >> 2] + 1j * (-3, -1, 3, 1)[i & 3]) / 10 ** 0.5 for i in range(16)], list(range(16)), 4, 1)
    comment: '16-QAM with the Gray code of the transmitter: index i = 4 I + Q bits, levels -3 -1 3 1 for the Gray codes 00 01 10 11. The slicer gives the index i (0 .. 15) as one byte'
  states: {}
- name: eq_alpha
  id: variable
  parameters:
    value: '0.6'
    comment: 'how fast the equalizer follows the channel (decision directed, per subcarrier): the stock default 0.1 is too slow for the phase drift of a B210 recorded by the P501; 0.5 to 0.7 works, 1 is too noisy. It is read when the flowgraph starts'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 0, eq_alpha)
    comment: 'the equalizer: one tap per subcarrier, updated from the decisions, and the common phase and the slope across the 4 pilots of every symbol'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    num_tabs: '6'
    label0: 1 Received signal
    label1: 2 Frame detection (stock S&C)
    label2: 3 Carrier offset
    label3: 4 FFT
    label4: 5 Channel estimate
    label5: 6 Equalizer and decisions
    gui_hint: 2,0,1,6
    comment: one tab per stage of the receiver
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: raise it until the received spectrum is clearly above the noise and the constellation is clean; lower it if the samples clip
    gui_hint: 0,0,1,3
    label: B210 RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: the stock detector fires when M = |S|^2 / R^2 reaches this value (stock default 0.9; 0.8 leaves room for the dither below, which lowers M of the real S&C symbol to about 0.97)
    gui_hint: 0,3,1,3
    label: S&C detection threshold (stock block)
    start: '0.3'
    step: '0.01'
    stop: '0.99'
    value: '0.8'
  states: {}
- name: dither_level
  id: variable_qtgui_range
  parameters:
    comment: 'noise added to the input of the S&C block only (the data do not get it), at this fraction of the signal level. The stock block has no energy guard: the idle slot of the P501 frame (80 samples at -15 dB, not pure noise) still looks like two equal halves and fires the detector one symbol before the real S&C symbol, so every frame is cut 80 samples early. The noise destroys that periodicity; the S&C symbol is about 15 dB stronger and keeps M close to 1. 0 = off. 0.08 to 0.2 was tested at three signal levels and decodes every frame; a much larger value lowers M of the real S&C symbol until it stays under the threshold and no frame is found'
    gui_hint: 1,3,1,3
    label: detector dither (fraction of the signal level)
    start: '0'
    step: '0.01'
    stop: '0.4'
    value: '0.12'
  states: {}
- name: cfo_frames
  id: variable_qtgui_range
  parameters:
    comment: the carrier offset that the stock S&C block gives is read at one sample of the plateau and scatters by 1 to 2 kHz from frame to frame; the oscillators of the P501 and the B210 are stable, so it is averaged over this many frames (a one-pole low-pass). The first frames after the start are wrong while the average settles
    gui_hint: 1,0,1,3
    label: carrier offset averaging (frames)
    rangeType: int
    start: '1'
    step: '1'
    stop: '60'
    value: '13'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: the B210 receiver (RX2 port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: file_source_0
  id: blocks_file_source
  parameters:
    file: capture_file
    type: complex
    repeat: 'True'
    comment: 'disabled: enable it (and the Throttle) and disable the B210 to replay a recording'
  states: {state: disabled}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
    comment: the file is read at the sample rate of the B210
  states: {state: disabled}
- name: rx_in
  id: blocks_copy
  parameters:
    type: complex
    comment: 'the one entry point of the receiver: the B210 (enabled) or the recording (enable the File Source and the Throttle, disable the B210)'
  states: {}
- name: dc_iir
  id: single_pole_iir_filter_xx
  parameters:
    type: complex
    alpha: '1e-4'
    comment: 'the DC offset (the local oscillator leakage of the B210, the spike at 0 Hz of the spectrum) as a very slow low-pass: the time constant is 10000 samples'
  states: {}
- name: dc_sub
  id: blocks_sub_xx
  parameters:
    type: complex
    comment: x minus its DC. the B210 DC leakage would otherwise add to every window (see also the detector dither below)
  states: {}
- name: dith_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|x| ...'
  states: {}
- name: dith_lvl
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: '2.4e-4'
    comment: '... averaged over about one frame (time constant 4096 samples): the signal level'
  states: {}
- name: dith_f2c
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: dith_noise
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: '1'
    seed: '7'
    comment: white noise, unit amplitude
  states: {}
- name: dith_mult
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: noise x signal level
  states: {}
- name: dith_k
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: dither_level
    comment: x dither fraction
  states: {}
- name: dith_add
  id: blocks_add_xx
  parameters:
    type: complex
    comment: 'the input of the stock S&C block: the signal plus the dither'
  states: {}
- name: x_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|x| after the DC removal: the frames (3760 active samples of 3840) with the idle slot between them'
  states: {}
- name: freq_sink_rx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: tabs@0:0,0,1,1
    label1: B210 RX2
    legend: 'False'
    name: '"received spectrum (raw): 28 subcarriers of 60 kHz = 1.7 MHz wide; the spike at 0 is the DC / LO leakage"'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@0:1,0,1,1
    label1: '|x|'
    legend: 'False'
    name: '"received signal |x| (two frames of 3840 samples = 1 ms each)"'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymin: '0'
  states: {}
- name: sync
  id: digital_ofdm_sync_sc_cfb
  parameters:
    fft_len: fft_len
    cp_len: cp_len
    use_even_carriers: 'True'
    threshold: threshold
    comment: 'STOCK BLOCK: Schmidl and Cox synchroniser (a hierarchical block made of delay, multiply, moving average and a peak detector, see gr-digital). Output 0: the carrier offset (fraction of a subcarrier, read at the peak of the metric, held until the next frame). Output 1: 1 at the start of the first symbol after the S&C symbol. ''Even'' carriers: the S&C symbol of this frame loads the even subcarriers'
  states: {}
- name: detect_f
  id: blocks_char_to_float
  parameters:
    scale: '1'
    comment: the detect pulses as numbers for the plot
  states: {}
- name: x_mag2
  id: blocks_complex_to_mag
  parameters:
    comment: '|x| for the plot'
  states: {}
- name: time_sink_det
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@1:0,0,1,1
    label1: '|x| (x 5)'
    label2: detect
    legend: 'False'
    name: '"|x| and the detect pulses of the stock S&C block (two frames of 3840 samples = 1 ms each)"'
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: ''
    ymax: '1.2'
    ymin: '-0.1'
  states: {}
- name: x_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '5'
  states: {}
- name: cfo_hz_raw
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: samp_rate / (3.141592653589793 * fft_len)
    comment: 'the output of the S&C block in Hz: output x samp_rate / (pi N)'
  states: {}
- name: cfo_avg
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: 1.0 / (cfo_frames * 3840)
    comment: the average over about cfo_frames frames; this is the offset that is applied
  states: {}
- name: cfo_hz_avg
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: samp_rate / (3.141592653589793 * fft_len)
  states: {}
- name: time_sink_cfo
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@2:0,0,1,1
    label1: S&C block
    label2: averaged
    legend: 'False'
    name: '"carrier offset (Hz): the value of the S&C block for every frame (blue) and the average that is applied (red)"'
    nconnections: '2'
    size: '32768'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Hz
    ymax: '20000'
    ymin: '-20000'
  states: {}
- name: osc
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0 / fft_len'
    comment: 'exp(-j 2 pi f n): the corrector. The offset in units of the block times -2/N is the phase step per sample'
  states: {}
- name: rot
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: x delayed by one symbol times the corrector
  states: {}
- name: sym_delay
  id: blocks_delay
  parameters:
    type: complex
    delay: fft_len + cp_len
    comment: the S&C block gives its result one symbol after the start of the frame; the samples wait for it, then the frame starts at the first sample of the header
  states: {}
- name: hpd
  id: digital_header_payload_demux
  parameters:
    header_len: '3'
    items_per_symbol: fft_len
    guard_interval: cp_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    type: complex
    timing_tag_key: '""'
    samp_rate: samp_rate
    special_tags: ()
    header_padding: '0'
    comment: 'STOCK BLOCK: cuts the frame. The trigger from the S&C block starts it; the first 3 symbols (S&C, T1, T2) go to output 0 (the header), then it waits for the message ''header_data'' that says how many symbols follow, and the payload goes to output 1. One output item = one OFDM symbol of 64 values, without the cyclic prefix'
  states: {}
- name: fft_hdr
  id: fft_vxx
  parameters:
    type: complex
    fft_size: fft_len
    forward: 'True'
    window: ()
    shift: 'True'
    comment: 'STOCK: FFT of the 3 header symbols; shift: the bin k + 32 holds subcarrier k'
  states: {}
- name: chanest
  id: digital_ofdm_chanest_vcvc
  parameters:
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
    n_data_symbols: '1'
    force_one_symbol: 'False'
    comment: 'STOCK BLOCK: from the S&C symbol it finds an integer carrier offset (whole subcarriers; none here) and from T1 the channel H[k] = received / known; it passes T2 on, with the channel as a tag'
  states: {}
- name: hdr
  id: epy_block
  parameters:
    nsym: '44'
    _source_code: |
      """Header stand-in. The stock receiver chain expects a header with the length of the packet after the synchronisation symbols; this frame has none: it always has 44 data symbols after S&C, T1 and T2.
      Input: the third symbol of every frame (T2) after the FFT and the channel estimator, 64 values, with the tags of the channel estimator. For every frame it sends the message that the Header/Payload Demux waits for:
      frame_length = nsym data symbols, and the channel estimate and the carrier offset of the tags (the equalizer of the payload needs them). Output: the channel estimate H[k] of the frame (64 values, DC in the middle, zero on the unused subcarriers) for the plots."""
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, nsym=44):
              gr.sync_block.__init__(self, name="Header stand-in (fixed frame length)", in_sig=[(np.complex64, 64)], out_sig=[(np.complex64, 64)])
              self.nsym = nsym
              self.frames = 0
              self.message_port_register_out(pmt.intern("header_data"))

          def work(self, input_items, output_items):
              n0 = self.nitems_read(0); n = len(input_items[0]); out = output_items[0]
              out[:] = 0
              for i in range(n):
                  d = pmt.make_dict()
                  d = pmt.dict_add(d, pmt.intern("frame_length"), pmt.from_long(int(self.nsym)))
                  for t in self.get_tags_in_range(0, n0 + i, n0 + i + 1):
                      d = pmt.dict_add(d, t.key, t.value)
                      if pmt.symbol_to_string(t.key) == "ofdm_sync_chan_taps":
                          out[i] = np.array(pmt.c32vector_elements(t.value), dtype=np.complex64)
                  self.message_port_pub(pmt.intern("header_data"), d)
                  self.frames += 1
              return n
    comment: 'the one block that the stock chain cannot do for this frame: the stock receiver reads the length of the packet from a header; this frame has none (44 data symbols, always), so this block sends that message for every frame. It also outputs the channel estimate for the plots'
  states: {}
- name: h_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: '64'
  states: {}
- name: h_arg
  id: blocks_complex_to_arg
  parameters:
    vlen: '64'
  states: {}
- name: vec_hmag
  id: qtgui_vector_sink_f
  parameters:
    name: '"channel |H[k]| (the unused subcarriers are 0)"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"|H|"'
    ymin: '0'
    ymax: '2'
    autoscale: 'True'
    gui_hint: tabs@4:0,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: vec_harg
  id: qtgui_vector_sink_f
  parameters:
    name: '"channel phase arg H[k] (rad): a straight line = a delay (the timing offset and the early FFT window)"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"rad"'
    ymin: '-3.2'
    ymax: '3.2'
    gui_hint: tabs@4:1,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: fft_pay
  id: fft_vxx
  parameters:
    type: complex
    fft_size: fft_len
    forward: 'True'
    window: ()
    shift: 'True'
    comment: 'STOCK: FFT of every data symbol (the prefix is already removed by the demux)'
  states: {}
- name: fft_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '[1.0 / 8.0] * 64'
    vlen: '64'
    comment: '1 / sqrt(64): a subcarrier of unit power gives a bin of unit power (only for the plots; the equalizer does not care)'
  states: {}
- name: fft_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: '64'
  states: {}
- name: fft_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '64'
    scale: 1.0 / 64
    max_iter: '4000'
    vlen: '64'
    comment: 'the mean of |FFT| of 64 symbols: the occupied band of 28 subcarriers (k = -14 .. +14)'
  states: {}
- name: vec_fft
  id: qtgui_vector_sink_f
  parameters:
    name: '"|FFT| of the OFDM symbols (mean of 64 symbols): subcarrier k = bin - 32"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"|X[k]|"'
    ymin: '0'
    ymax: '3'
    gui_hint: tabs@3:0,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: v2s64
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: keep29
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: '29'
    n: '64'
    offset: '18'
    comment: the used subcarriers k = -14 .. +14 (29 bins, including the unused DC) of the 64
  states: {}
- name: const_raw
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@3:1,0,1,1
    label1: symbols
    legend: 'False'
    name: '"after the FFT, before the equalizer (used subcarriers: the channel and the carrier rotate and scale the points)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: eq
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    fft_len: fft_len
    cp_len: cp_len
    equalizer: payload_equalizer.base()
    len_tag_key: length_tag_key
    propagate_channel_state: 'False'
    comment: 'STOCK BLOCK: equalizer. Takes the channel taps from the tag, divides every subcarrier by its tap, corrects the common phase and the slope with the 4 pilots of the symbol, and updates the taps from its own decisions (weight eq_alpha)'
  states: {}
- name: ser
  id: digital_ofdm_serializer_vcc
  parameters:
    fft_len: fft_len
    occupied_carriers: occupied_carriers
    len_tag_key: length_tag_key
    comment: 'STOCK BLOCK: takes the 24 data subcarriers out of the 64 and puts them in a row: 24 values per symbol, 44 symbols per frame = 1056 per frame'
  states: {}
- name: const_eq
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@5:0,2,2,2
    label1: symbols
    legend: 'False'
    name: '"the decided symbols (the stock equalizer outputs its decisions, so this is always clean: the error counters tell the quality)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: dec
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
    comment: 'STOCK BLOCK: the 16-QAM slicer, one byte (0 .. 15) per symbol'
  states: {}
- name: counter
  id: epy_block
  parameters:
    _source_code: |
      """Symbol error counter. The payload of every frame is the PRBS-15 (x^15 + x^14 + 1, seed 0x7FFF, 4 bits per 16-QAM symbol, the first bit pair = I) restarted in every frame: 44 symbols x 24 subcarriers = 1056 values.
      Every frame of 1056 slicer bytes is compared with it (a rejected frame, bytes of 255, is skipped). Outputs (one value per input byte): 0: symbol error rate since the start, 1: symbol errors, 2: frames decoded, 3: symbol error rate over the last 2000 frames (what the link does now, not what happened at the start)."""
      import collections
      import numpy as np
      from gnuradio import gr

      NPAY = 1056


      def prbs15_symbols(n):
          s, bits = 0x7FFF, []
          for _ in range(4 * n):
              bits.append((s >> 14) & 1); s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)
          b = np.array(bits, int).reshape(n, 4)
          return (b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]).astype(np.uint8)


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="Symbol error counter", in_sig=[np.uint8], out_sig=[np.float32, np.float32, np.float32, np.float32])
              self.ref = prbs15_symbols(NPAY)
              self.sym = 0; self.err = 0; self.frames = 0
              self.recent = collections.deque(maxlen=2000)
              self.set_output_multiple(NPAY)

          def work(self, input_items, output_items):
              x = input_items[0]; nf = len(output_items[0]) // NPAY
              for f in range(nf):
                  fr = x[f * NPAY:(f + 1) * NPAY]
                  if not np.any(fr == 255):
                      ne = int(np.count_nonzero(fr != self.ref)); self.err += ne; self.sym += NPAY; self.frames += 1; self.recent.append(ne)
                  sl = slice(f * NPAY, (f + 1) * NPAY)
                  output_items[0][sl] = self.err / self.sym if self.sym else 0.0; output_items[1][sl] = self.err; output_items[2][sl] = self.frames; output_items[3][sl] = sum(self.recent) / (NPAY * len(self.recent)) if self.recent else 0.0
              return nf * NPAY
    comment: 'compares every frame with the PRBS-15 payload that the transmitter sends: symbol errors since the start, symbol error rate, frames decoded (as in ofdm_b210_frame_rx.grc, with a fourth output: the error rate over the last 2000 frames)'
  states: {}
- name: keep_ser
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '1056'
  states: {}
- name: number_ser
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,0,1,1
    label1: SER
    min: '0'
    name: '"symbol error rate (since the start)"'
    type: float
    update_time: '0.25'
  states: {}
- name: keep_err
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '1056'
  states: {}
- name: number_err
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,1,1,1
    label1: errors
    min: '0'
    name: '"symbol errors"'
    type: float
    update_time: '0.25'
  states: {}
- name: keep_frames
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '1056'
  states: {}
- name: number_frames
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,2,1,1
    label1: frames
    min: '0'
    name: '"frames decoded"'
    type: float
    update_time: '0.25'
  states: {}
- name: keep_recent
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '1056'
  states: {}
- name: number_recent
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,3,1,1
    label1: SER now
    min: '0'
    name: '"symbol error rate, last 2000 frames (about 2 s)"'
    type: float
    update_time: '0.25'
  states: {}
- name: soft
  id: epy_block
  parameters:
    smooth: '5'
    _source_code: |
      """Soft equalizer for the plots (the stock equalizer outputs only its decisions, so its constellation is always perfect). Input: the FFT of the data symbols (64 values per symbol, DC in the middle) of the Header/Payload Demux, 44 symbols
      per frame; the first symbol of a frame carries the tag ofdm_sync_chan_taps (the channel estimate of the stock channel estimator). For every symbol:
        1. Z[k] = Y[k] / H[k] on the 24 data subcarriers and the 4 pilots (k = -11, -4, 4, 11)
        2. the pilots must be PIL_V x polarity of the symbol (QPSK, PRBS-7 of IEEE 802.11): the phase of Z[pilot] conj(reference) against k is a straight line, its slope is a timing drift; the mean of the 4 pilots is the common complex gain g
        3. slope and g are averaged over `smooth` symbols (centred), the data are divided by g and turned back by the slope.
      Outputs: 0: the 24 soft data values per symbol (no decisions); 1: the error vector magnitude in dB, measured against the PRBS-15 payload that the transmitter sends, as a running average over about 30 frames (frames with an error above -6 dB, wrong cuts or the start-up, are not counted)."""
      import numpy as np
      from gnuradio import gr

      L_SYM = 44
      KP = np.array([-11, -4, 4, 11]); KD = np.array([k for k in range(-14, 15) if k != 0 and k not in (-11, -4, 4, 11)])
      IP, ID = 32 + KP, 32 + KD
      PIL_V = np.array([1 + 1j, 1 - 1j, -1 + 1j, -1 - 1j]) / np.sqrt(2)
      POL = np.array([-1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, -1], float)
      REF_P = PIL_V[None, :] * POL[:, None]
      GRAY = np.array([-3, -1, 3, 1]) / np.sqrt(10)


      def prbs15_symbols(n):
          s, bits = 0x7FFF, []
          for _ in range(4 * n):
              bits.append((s >> 14) & 1); s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)
          b = np.array(bits, int).reshape(n, 4)
          return b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]


      IDX = prbs15_symbols(L_SYM * 24)
      REF_D = (GRAY[IDX >> 2] + 1j * GRAY[IDX & 3]).reshape(L_SYM, 24)


      def smoothing_matrix(n, L=L_SYM):
          if n <= 1: return np.eye(L)
          w = np.ones(n); M = np.zeros((L, L))
          for j in range(L): M[:, j] = np.convolve(np.eye(L)[j], w, "same")
          return M / M.sum(axis=1, keepdims=True)


      class blk(gr.sync_block):
          def __init__(self, smooth=5):
              gr.sync_block.__init__(self, name="Soft equalizer (for the plots)", in_sig=[(np.complex64, 64)], out_sig=[(np.complex64, 24), np.float32])
              self.smooth = smooth
              self.set_output_multiple(L_SYM)
              self.pw = None

          @property
          def smooth(self):
              return self._smooth

          @smooth.setter
          def smooth(self, v):
              self._smooth = int(v); self.M = smoothing_matrix(self._smooth)

          def work(self, input_items, output_items):
              y = input_items[0]; z = output_items[0]; ev = output_items[1]
              n0 = self.nitems_read(0); nf = len(y) // L_SYM
              tags = {t.offset: t for t in self.get_tags_in_window(0, 0, nf * L_SYM) if t.key.__str__() == "ofdm_sync_chan_taps"}
              import pmt
              for f in range(nf):
                  sl = slice(f * L_SYM, (f + 1) * L_SYM); t = tags.get(n0 + f * L_SYM)
                  if t is None:
                      z[sl] = 0; ev[sl] = ev[f * L_SYM - 1] if f else 0.0; continue
                  H = np.array(pmt.c32vector_elements(t.value), dtype=complex)
                  Y = y[sl].astype(complex)
                  with np.errstate(divide="ignore", invalid="ignore"):
                      Zp = Y[:, IP] / H[IP]; Zd = Y[:, ID] / H[ID]
                  if not (np.all(np.isfinite(Zp)) and np.all(np.isfinite(Zd))): z[sl] = 0; continue
                  ph = np.unwrap(np.angle(Zp * np.conj(REF_P)), axis=1)
                  sl_k = (ph @ KP) / np.sum(KP ** 2)                                    # least squares slope (the 4 pilots are symmetric around k = 0)
                  sl_k = self.M @ sl_k
                  g = np.mean(Zp * np.conj(REF_P) * np.exp(-1j * sl_k[:, None] * KP[None, :]), axis=1); g = self.M @ g
                  out = Zd * np.exp(-1j * sl_k[:, None] * KD[None, :]) / g[:, None]
                  z[sl] = out
                  e = np.mean(np.abs(out - REF_D) ** 2) / np.mean(np.abs(REF_D) ** 2)
                  if e < 0.25: self.pw = e if self.pw is None else 0.97 * self.pw + 0.03 * e
                  ev[sl] = 10 * np.log10(max(self.pw, 1e-12)) if self.pw is not None else 0.0
              return nf * L_SYM
    comment: 'the one block that is not stock in the payload chain: the stock equalizer outputs only its decisions (a perfect constellation whatever the noise), so this one equalizes the same FFT output with the channel estimate and the 4 pilots and keeps the received values for the plot, and measures the EVM against the known payload'
  states: {}
- name: v2s_soft
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '24'
  states: {}
- name: keep_soft
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '8'
    comment: every 8th point is enough for the plot
  states: {}
- name: const_soft
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@5:0,0,2,2
    label1: symbols
    legend: 'False'
    name: '"the received data symbols after the soft equalizer: the spread of the clusters is the noise (the channel is divided out, the pilots remove the phase and gain)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: keep_evm
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '1056'
  states: {}
- name: number_evm
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,4,1,1
    label1: EVM
    min: '0'
    name: '"EVM against the known payload (dB)"'
    type: float
    unit1: dB
    update_time: '0.25'
  states: {}
- name: soft_v2s
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: soft_keep
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: 44 * 64
    n: 44 * 64 * soft_n
    offset: '0'
    comment: 'a Python block cannot follow 1000 frames per second in real time (the B210 would overflow): 1 whole frame (44 symbols x 64 values) in soft_n goes to the soft equalizer'
  states: {}
- name: soft_s2v
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: soft_n
  id: variable
  parameters:
    value: '8'
    comment: 'the soft equalizer (the plot and the EVM) looks at 1 frame in soft_n: 125 frames per second. The decisions and the error counters use every frame'
  states: {}

connections:
- [uhd_usrp_source_0, '0', rx_in, '0']
- [file_source_0, '0', throttle_0, '0']
- [throttle_0, '0', rx_in, '0']
- [rx_in, '0', dc_iir, '0']
- [rx_in, '0', dc_sub, '0']
- [dc_iir, '0', dc_sub, '1']
- [dc_sub, '0', dith_mag, '0']
- [dith_mag, '0', dith_lvl, '0']
- [dith_lvl, '0', dith_f2c, '0']
- [dith_f2c, '0', dith_mult, '0']
- [dith_noise, '0', dith_mult, '1']
- [dith_mult, '0', dith_k, '0']
- [dc_sub, '0', dith_add, '0']
- [dith_k, '0', dith_add, '1']
- [dc_sub, '0', x_mag, '0']
- [rx_in, '0', freq_sink_rx, '0']
- [x_mag, '0', time_sink_rx, '0']
- [dith_add, '0', sync, '0']
- [x_mag2, '0', x_scale, '0']
- [dc_sub, '0', x_mag2, '0']
- [x_scale, '0', time_sink_det, '0']
- [sync, '1', detect_f, '0']
- [detect_f, '0', time_sink_det, '1']
- [sync, '0', cfo_hz_raw, '0']
- [sync, '0', cfo_avg, '0']
- [cfo_avg, '0', cfo_hz_avg, '0']
- [cfo_hz_raw, '0', time_sink_cfo, '0']
- [cfo_hz_avg, '0', time_sink_cfo, '1']
- [cfo_avg, '0', osc, '0']
- [dc_sub, '0', sym_delay, '0']
- [sym_delay, '0', rot, '0']
- [osc, '0', rot, '1']
- [rot, '0', hpd, '0']
- [sync, '1', hpd, '1']
- [hpd, '0', fft_hdr, '0']
- [fft_hdr, '0', chanest, '0']
- [chanest, '0', hdr, '0']
- [hdr, header_data, hpd, header_data]
- [hdr, '0', h_mag, '0']
- [hdr, '0', h_arg, '0']
- [h_mag, '0', vec_hmag, '0']
- [h_arg, '0', vec_harg, '0']
- [hpd, '1', fft_pay, '0']
- [fft_pay, '0', fft_scale, '0']
- [fft_scale, '0', fft_mag, '0']
- [fft_mag, '0', fft_avg, '0']
- [fft_avg, '0', vec_fft, '0']
- [fft_scale, '0', v2s64, '0']
- [v2s64, '0', keep29, '0']
- [keep29, '0', const_raw, '0']
- [counter, '0', keep_ser, '0']
- [keep_ser, '0', number_ser, '0']
- [counter, '1', keep_err, '0']
- [keep_err, '0', number_err, '0']
- [counter, '2', keep_frames, '0']
- [keep_frames, '0', number_frames, '0']
- [counter, '3', keep_recent, '0']
- [keep_recent, '0', number_recent, '0']
- [fft_pay, '0', eq, '0']
- [eq, '0', ser, '0']
- [ser, '0', const_eq, '0']
- [ser, '0', dec, '0']
- [dec, '0', counter, '0']
- [fft_pay, '0', soft_v2s, '0']
- [soft_v2s, '0', soft_keep, '0']
- [soft_keep, '0', soft_s2v, '0']
- [soft_s2v, '0', soft, '0']
- [soft, '0', v2s_soft, '0']
- [v2s_soft, '0', keep_soft, '0']
- [keep_soft, '0', const_soft, '0']
- [soft, '1', keep_evm, '0']
- [keep_evm, '0', number_evm, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
