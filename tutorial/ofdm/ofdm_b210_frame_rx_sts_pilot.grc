options:
  parameters:
    author: p501_fft_example
    description: 'Like ofdm_b210_frame_rx_sts_stock.grc, but the stock Frame Equalizer (decision directed channel update, 4.7e-4 symbol errors on a recording of the B210 receiving the P501) is replaced by a block of our own (pilot_eq.py): the channel from the training symbol, the common phase and gain of every symbol from the 4 pilots, no feedback from the decisions.'
    generate_options: qt_gui
    id: ofdm_b210_frame_rx_sts_pilot
    output_language: python
    title: 'B210 receiver: OFDM frames with the 128-sample STS preamble, stock blocks and a pilot equalizer of our own'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3840000'
    comment: '3.84 MS/s: the sample rate of the P501 and of the OFDM frames; N = 64 subcarriers of 60 kHz'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 850e6
    comment: 'carrier: the same as the transmitter''s (the P501 notebook P501_OFDM_Live or ofdm_b210_frame_tx.grc); check the rules where you are before transmitting'
  states: {}
- name: capture_file
  id: variable
  parameters:
    value: '"ofdm_b210_capture_sts.c64"'
    comment: a recording of the B210 samples (complex float, 3.84 MS/s) for the File Source (disabled by default) instead of the B210
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
    comment: FFT length N
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '16'
    comment: cyclic prefix, in samples
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_length"'
    comment: the tag that carries the number of OFDM symbols of the payload through the receiver
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: ([-14, -13, -12, -10, -9, -8, -7, -6, -5, -3, -2, -1, 1, 2, 3, 5, 6, 7, 8, 9, 10, 12, 13, 14],)
    comment: the 24 data subcarriers (k = -14 .. +14 without 0 and without the pilots), in the order of the transmitter
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ([-11, -4, 4, 11],)
    comment: the 4 pilot subcarriers
  states: {}
- name: pilot_polarity
  id: variable
  parameters:
    value: '[-1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, -1]'
    comment: the sign of the pilots in every one of the 44 data symbols (PRBS-7 of IEEE 802.11)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: tuple(tuple(p * v for v in ((0.707106781187+0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j))) for p in pilot_polarity)
    comment: 'the pilot values of every data symbol: QPSK, times the polarity. The stock equalizer takes one list of 4 values per symbol and repeats the list when the frame is longer'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_calcdist([((-3, -1, 3, 1)[i >> 2] + 1j * (-3, -1, 3, 1)[i & 3]) / 10 ** 0.5 for i in range(16)], list(range(16)), 4, 1)
    comment: '16-QAM with the Gray code of the transmitter: index i = 4 I + Q bits, levels -3 -1 3 1 for the Gray codes 00 01 10 11. The slicer gives the index i (0 .. 15) as one byte'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    num_tabs: '6'
    label0: 1 Received signal
    label1: '"2 Frame detection (STS)"'
    label2: '"3 Carrier offset"'
    label3: 4 FFT
    label4: 5 Channel estimate
    label5: 6 Equalizer and decisions
    gui_hint: 2,0,1,6
    comment: one tab per stage of the receiver
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: raise it until the received spectrum is clearly above the noise and the constellation is clean; lower it if the samples clip
    gui_hint: 0,0,1,3
    label: B210 RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: 'the frame is found when M = |S|^2 / (Ea Eb + guard) reaches this value (the FPGA uses 0.65). The energy guard of the first receiver makes the idle slot of the P501 frame harmless: no dither is needed here, the stock Schmidl-and-Cox block had none'
    gui_hint: 0,3,1,3
    label: '"STS detection threshold (metric M)"'
    start: '0.3'
    step: '0.01'
    stop: '0.95'
    value: '0.65'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: the B210 receiver (RX2 port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: file_source_0
  id: blocks_file_source
  parameters:
    file: capture_file
    type: complex
    repeat: 'True'
    comment: 'disabled: enable it (and the Throttle) and disable the B210 to replay a recording'
  states: {state: disabled}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
    comment: the file is read at the sample rate of the B210
  states: {state: disabled}
- name: rx_in
  id: blocks_copy
  parameters:
    type: complex
    comment: 'the one entry point of the receiver: the B210 (enabled) or the recording (enable the File Source and the Throttle, disable the B210)'
  states: {}
- name: dc_iir
  id: single_pole_iir_filter_xx
  parameters:
    type: complex
    alpha: '1e-4'
    comment: 'the DC offset (the local oscillator leakage of the B210, the spike at 0 Hz of the spectrum) as a very slow low-pass: the time constant is 10000 samples'
  states: {}
- name: dc_sub
  id: blocks_sub_xx
  parameters:
    type: complex
    comment: x minus its DC. the B210 DC leakage would otherwise add to every window (see also the detector dither below)
    minoutbuf: '262144'
  states: {}
- name: x_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|x| after the DC removal: the frames (3760 active samples of 3840) with the idle slot between them'
  states: {}
- name: freq_sink_rx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: tabs@0:0,0,1,1
    label1: B210 RX2
    legend: 'False'
    name: '"received spectrum (raw): 28 subcarriers of 60 kHz = 1.7 MHz wide; the spike at 0 is the DC / LO leakage"'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@0:1,0,1,1
    label1: '|x|'
    legend: 'False'
    name: '"received signal |x| (two frames of 3840 samples = 1 ms each)"'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymin: '0'
  states: {}
- name: detect_f
  id: blocks_char_to_float
  parameters:
    scale: '1'
    comment: the detect pulses as numbers for the plot
  states: {}
- name: x_mag2
  id: blocks_complex_to_mag
  parameters:
    comment: '|x| for the plot'
  states: {}
- name: time_sink_det
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@1:0,0,1,1
    label1: '|x| (x 5)'
    label2: '"trigger"'
    legend: 'False'
    name: '"|x| and the trigger of the STS synchroniser (two frames of 3840 samples = 1 ms each)"'
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: ''
    ymax: '1.2'
    ymin: '-0.1'
  states: {}
- name: x_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '5'
  states: {}
- name: cfo_hz_raw
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: samp_rate / (3.141592653589793 * fft_len)
    comment: 'the carrier offset of the synchroniser in Hz: output x samp_rate / (pi N)'
  states: {}
- name: time_sink_cfo
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@2:0,0,1,1
    label1: '"measured"'
    legend: 'False'
    name: '"carrier offset (Hz) measured for every frame: coarse from the STS, fine from the two training symbols"'
    size: '32768'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: Hz
    ymax: '20000'
    ymin: '-20000'
  states: {}
- name: osc
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0 / fft_len'
    comment: 'exp(-j 2 pi f n): the corrector. The offset in the units of the synchroniser times -2/N is the phase step per sample'
  states: {}
- name: rot
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: x delayed by one symbol times the corrector
  states: {}
- name: sym_delay
  id: blocks_delay
  parameters:
    type: complex
    delay: sync_delay
    comment: 'the samples wait for the synchroniser (the training symbols end 282 samples after the start of the STS): then the carrier is known when they pass the oscillator'
  states: {}
- name: hpd
  id: digital_header_payload_demux
  parameters:
    header_len: '2'
    items_per_symbol: fft_len
    guard_interval: cp_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    type: complex
    timing_tag_key: '""'
    samp_rate: samp_rate
    special_tags: ()
    header_padding: '0'
    comment: 'STOCK BLOCK: cuts the frame. The trigger of the synchroniser (122 samples after the start of the STS) starts it; after the guard interval of 16 samples the 2 header symbols (the windows at s0 + 138, a training symbol read 10 samples late, and s0 + 218, the second training symbol) go to output 0, then it waits for the message ''header_data'' (always 44 symbols) and the 44 data symbols (the windows at s0 + 298 + 80 l) go to output 1'
  states: {}
- name: fft_hdr
  id: fft_vxx
  parameters:
    type: complex
    fft_size: fft_len
    forward: 'True'
    window: ()
    shift: 'True'
    comment: 'STOCK: FFT of the 3 header symbols; shift: the bin k + 32 holds subcarrier k'
  states: {}
- name: chanest
  id: digital_ofdm_chanest_vcvc
  parameters:
    sync_symbol1: sync_word
    sync_symbol2: sync_word
    n_data_symbols: '1'
    force_one_symbol: 'True'
    comment: 'STOCK BLOCK: channel estimate H[k] = received / known from the first header symbol (one training symbol: force one sync symbol; the sync word is given twice because the block uses the second one to find the active subcarriers); the second header symbol passes with H as a tag'
  states: {}
- name: hdr
  id: epy_block
  parameters:
    nsym: '44'
    _source_code: |
      """Header stand-in. The stock receiver chain expects a header with the length of the packet after the synchronisation symbols; this frame has none: it always has 44 data symbols after S&C, T1 and T2.
      Input: the third symbol of every frame (T2) after the FFT and the channel estimator, 64 values, with the tags of the channel estimator. For every frame it sends the message that the Header/Payload Demux waits for:
      frame_length = nsym data symbols, and the channel estimate and the carrier offset of the tags (the equalizer of the payload needs them). Output: the channel estimate H[k] of the frame (64 values, DC in the middle, zero on the unused subcarriers) for the plots."""
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, nsym=44):
              gr.sync_block.__init__(self, name="Header stand-in (fixed frame length)", in_sig=[(np.complex64, 64)], out_sig=[(np.complex64, 64)])
              self.nsym = nsym
              self.frames = 0
              self.message_port_register_out(pmt.intern("header_data"))

          def work(self, input_items, output_items):
              n0 = self.nitems_read(0); n = len(input_items[0]); out = output_items[0]
              out[:] = 0
              for i in range(n):
                  d = pmt.make_dict()
                  d = pmt.dict_add(d, pmt.intern("frame_length"), pmt.from_long(int(self.nsym)))
                  for t in self.get_tags_in_range(0, n0 + i, n0 + i + 1):
                      d = pmt.dict_add(d, t.key, t.value)
                      if pmt.symbol_to_string(t.key) == "ofdm_sync_chan_taps":
                          out[i] = np.array(pmt.c32vector_elements(t.value), dtype=np.complex64)
                  self.message_port_pub(pmt.intern("header_data"), d)
                  self.frames += 1
              return n
    comment: 'the stand-in for the packet header (the frame has none: always 44 data symbols): sends the message the Header/Payload Demux waits for, with the channel estimate of the tag, and outputs the estimate for the plots'
  states: {}
- name: h_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: '64'
  states: {}
- name: h_arg
  id: blocks_complex_to_arg
  parameters:
    vlen: '64'
  states: {}
- name: vec_hmag
  id: qtgui_vector_sink_f
  parameters:
    name: '"channel |H[k]| (the unused subcarriers are 0)"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"|H|"'
    ymin: '0'
    ymax: '2'
    autoscale: 'True'
    gui_hint: tabs@4:0,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: vec_harg
  id: qtgui_vector_sink_f
  parameters:
    name: '"channel phase arg H[k] (rad): a straight line = a delay (the timing offset and the early FFT window)"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"rad"'
    ymin: '-3.2'
    ymax: '3.2'
    gui_hint: tabs@4:1,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: fft_pay
  id: fft_vxx
  parameters:
    type: complex
    fft_size: fft_len
    forward: 'True'
    window: ()
    shift: 'True'
    comment: 'STOCK: FFT of every data symbol (the prefix is already removed by the demux)'
  states: {}
- name: fft_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '[1.0 / 8.0] * 64'
    vlen: '64'
    comment: '1 / sqrt(64): a subcarrier of unit power gives a bin of unit power (only for the plots; the equalizer does not care)'
  states: {}
- name: fft_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: '64'
  states: {}
- name: fft_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '64'
    scale: 1.0 / 64
    max_iter: '4000'
    vlen: '64'
    comment: 'the mean of |FFT| of 64 symbols: the occupied band of 28 subcarriers (k = -14 .. +14)'
  states: {}
- name: vec_fft
  id: qtgui_vector_sink_f
  parameters:
    name: '"|FFT| of the OFDM symbols (mean of 64 symbols): subcarrier k = bin - 32"'
    vlen: '64'
    x_start: '-32'
    x_step: '1'
    x_axis_label: '"subcarrier k"'
    y_axis_label: '"|X[k]|"'
    ymin: '0'
    ymax: '3'
    gui_hint: tabs@3:0,0,1,1
    update_time: '0.1'
    grid: 'True'
  states: {}
- name: v2s64
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: keep29
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: '29'
    n: '64'
    offset: '18'
    comment: the used subcarriers k = -14 .. +14 (29 bins, including the unused DC) of the 64
  states: {}
- name: const_raw
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@3:1,0,1,1
    label1: symbols
    legend: 'False'
    name: '"after the FFT, before the equalizer (used subcarriers: the channel and the carrier rotate and scale the points)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: const_eq
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@5:0,2,2,2
    label1: symbols
    legend: 'False'
    name: '"the decided points (the nearest of the 16: the error counters tell the quality)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: dec
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
    comment: 'STOCK BLOCK: the 16-QAM slicer, one byte (0 .. 15) per symbol'
  states: {}
- name: counter
  id: epy_block
  parameters:
    _source_code: |
      """Symbol error counter, one output value per frame. The payload of every frame is the PRBS-15 (x^15 + x^14 + 1, seed 0x7FFF, 4 bits per 16-QAM symbol, the first bit pair = I) restarted in every frame: 44 symbols x 24 subcarriers = 1056 values.
      Every frame of 1056 slicer bytes (0 .. 15) is compared with it (a rejected frame, bytes of 255, is skipped). Outputs, one value per frame: 0: symbol error rate since the start, 1: symbol errors since the start, 2: frames decoded,
      3: symbol error rate over the last 2000 frames (what the link does now). A decimating block with vectorised numpy: one value per frame instead of one per symbol keeps the Python interpreter, which the other Python blocks of the flowgraph share, free."""
      import numpy as np
      from gnuradio import gr

      NPAY = 1056


      def prbs15_symbols(n):
          s, bits = 0x7FFF, []
          for _ in range(4 * n):
              bits.append((s >> 14) & 1); s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)
          b = np.array(bits, int).reshape(n, 4)
          return (b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]).astype(np.uint8)


      class blk(gr.decim_block):
          def __init__(self):
              gr.decim_block.__init__(self, name="Symbol error counter (one value per frame)", in_sig=[np.uint8], out_sig=[np.float32, np.float32, np.float32, np.float32], decim=NPAY)
              self.ref = prbs15_symbols(NPAY)
              self.err = 0; self.frames = 0
              self.hist = np.zeros(0, np.int64)            # symbol errors of the last 2000 frames

          def work(self, input_items, output_items):
              nf = len(output_items[0])
              fr = input_items[0][:nf * NPAY].reshape(nf, NPAY)
              e = np.count_nonzero(fr != self.ref[None, :], axis=1).astype(np.int64)
              e[np.any(fr == 255, axis=1)] = -1                                           # rejected frames are not counted
              ok = e >= 0
              cum_e = self.err + np.cumsum(np.where(ok, e, 0)); cum_f = self.frames + np.cumsum(ok)
              allh = np.concatenate([self.hist, np.where(ok, e, 0)]); cs = np.concatenate([[0], np.cumsum(allh)]); k = len(self.hist) + np.arange(1, nf + 1); lo = np.maximum(k - 2000, 0)
              rec = (cs[k] - cs[lo]) / (NPAY * np.maximum(k - lo, 1))
              output_items[0][:] = np.where(cum_f > 0, cum_e / (NPAY * np.maximum(cum_f, 1)), 0.0); output_items[1][:] = cum_e; output_items[2][:] = cum_f; output_items[3][:] = rec
              self.err = int(cum_e[-1]); self.frames = int(cum_f[-1]); self.hist = allh[-2000:]
              return nf
    comment: 'compares every frame with the PRBS-15 payload that the transmitter sends: symbol errors since the start, symbol error rate, frames decoded, and the error rate over the last 2000 frames. It outputs ONE value per frame (a decimating block, vectorised): the version with one value per symbol took more of the Python interpreter than the rest of the receiver together and made the flowgraph too slow for the B210 (overflows)'
  states: {}
- name: number_ser
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,0,1,1
    label1: SER
    min: '0'
    name: '"symbol error rate (since the start)"'
    type: float
    update_time: '0.25'
  states: {}
- name: number_err
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,1,1,1
    label1: errors
    min: '0'
    name: '"symbol errors"'
    type: float
    update_time: '0.25'
  states: {}
- name: number_frames
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,2,1,1
    label1: '"frames"'
    min: '0'
    name: '"frames checked (1 in check_n)"'
    type: float
    update_time: '0.25'
  states: {}
- name: number_recent
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,3,1,1
    label1: SER now
    min: '0'
    name: '"symbol error rate, last 2000 checked frames (about 16 s)"'
    type: float
    update_time: '0.25'
  states: {}
- name: v2s_soft
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '24'
  states: {}
- name: keep_soft
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '8'
    comment: every 8th point is enough for the plot
  states: {}
- name: const_soft
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@5:0,0,2,2
    label1: symbols
    legend: 'False'
    name: '"the received data symbols after the equalizer: the spread of the clusters is the noise (the channel is divided out, the pilots remove the phase and gain)"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: keep_evm
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '1056'
  states: {}
- name: number_evm
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@5:2,4,1,1
    label1: EVM
    min: '0'
    name: '"EVM against the known payload (dB)"'
    type: float
    unit1: dB
    update_time: '0.25'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, (-0.707106781187+0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187+0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187+0.707106781187j), 0j, (-0.707106781187-0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (-0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187+0.707106781187j), (0.707106781187+0.707106781187j), (0.707106781187-0.707106781187j), (-0.707106781187+0.707106781187j), (-0.707106781187-0.707106781187j), (-0.707106781187-0.707106781187j), (0.707106781187+0.707106781187j), (0.707106781187+0.707106781187j), 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j, 0j]'
    comment: 'the training symbol as the channel estimator must see it: the 28 QPSK values of T times (-j)^k. The first header window of the demux starts at s0 + 138, ten samples into the LTS (the LTS is T repeated, so the window is T shifted circularly by 42 samples: a phase slope of 42 samples); the data windows start 6 samples inside their prefixes (a slope of -6 samples). The factor exp(j 2 pi k 48 / 64) = (-j)^k is the sum of the two, so that H = received / sync word has the phase slope of the data windows'
  states: {}
- name: sync_delay
  id: variable
  parameters:
    value: '384'
    comment: the samples wait this long (a Delay block) while the synchroniser measures the carrier from the two training symbols (they end 282 samples after the start of the STS); it must be at least 330
  states: {}
- name: guard_level
  id: variable
  parameters:
    value: '0.1'
    comment: 'energy guard: a window counts only if its energy is at least this fraction of the long-term average (0.1 = -10 dB). A constant, a DC offset or noise that is not much weaker than the signal looks like a periodic signal to the S&C metric (M reaches 1 in the idle slot) whatever its level; the FPGA has the same guard as an absolute level (EMIN)'
  states: {}
- name: sc_delay
  id: blocks_delay
  parameters:
    type: complex
    delay: '16'
    comment: 'x[n-16]: the STS repeats every 16 samples (6 QPSK subcarriers at k = +-4, +-8, +-12)'
  states: {}
- name: sc_conj
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: sc_mult
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: x[n] conj(x[n-32])
  states: {}
- name: sc_avg
  id: blocks_moving_average_xx
  parameters:
    type: complex
    length: '48'
    scale: '1'
    max_iter: '4000'
    comment: 'S[n] = sum of 48 products x[n] conj(x[n-16]): |S| is large when the last 64 samples are the periodic STS; its angle is 16 times the carrier offset per sample'
    minoutbuf: '262144'
  states: {}
- name: sc_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: '|S|^2'
  states: {}
- name: en_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: '|x|^2'
  states: {}
- name: en_avg
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '48'
    scale: '1'
    max_iter: '4000'
    comment: 'Eb: the energy of the newer 48 samples'
  states: {}
- name: en_delay
  id: blocks_delay
  parameters:
    type: float
    delay: '16'
    comment: 'Ea: the energy of the older 48 samples (the multiplied ones: 16 samples earlier)'
  states: {}
- name: en_mult
  id: blocks_multiply_xx
  parameters:
    type: float
    comment: 'Ea Eb: the normalisation. With |S|^2 / Eb^2 alone a strong frame that ends in noise would fire the detector (the P501 FPGA has a guard for this); Ea Eb keeps M <= 1'
  states: {}
- name: guard_avg
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: '2.4e-4'
    comment: the long-term average power P of the signal (time constant 4096 samples, about 1 frame)
  states: {}
- name: guard_sq
  id: blocks_multiply_xx
  parameters:
    type: float
    comment: P^2
  states: {}
- name: guard_k
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: (guard_level * 48) ** 2
    comment: '(guard_level 48 P)^2: the square of the smallest window energy that may count (see guard_level)'
  states: {}
- name: guard_add
  id: blocks_add_xx
  parameters:
    type: float
    comment: 'Ea Eb + guard: in the idle slot Ea Eb is far below the guard, so M = |S|^2 / (Ea Eb + guard) is small there whatever the content of the slot; in the frame Ea Eb is far above it and M is unchanged'
  states: {}
- name: en_eps
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1e-12'
    comment: avoids a division by zero
  states: {}
- name: sc_div
  id: blocks_divide_xx
  parameters:
    type: float
    comment: 'M[n] = |S|^2 / (Ea Eb + guard): about 1 (a plateau of 65 samples) when the last 64 samples are inside the STS, small everywhere else; the idle slot (80 samples at -15 dB, not pure noise) stays below the guard'
    minoutbuf: '262144'
  states: {}
- name: thr_src
  id: analog_const_source_x
  parameters:
    type: float
    const: threshold
    comment: the detection threshold, drawn with M
  states: {}
- name: time_sink_m
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@1:1,0,1,1
    label1: M
    label2: threshold
    legend: 'False'
    name: '"STS metric M and the threshold (two frames)"'
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: M
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: sts_sync
  id: epy_block
  parameters:
    _source_code: |
      """Frame synchroniser for the 128-sample STS frame (the part that the stock Schmidl-and-Cox block does for the S&C frame). Inputs: the received samples x, the timing metric M and the sum S of 48 products x[n] conj(x[n-16]),
      all aligned (the window of 64 samples ends at sample n; the stock blocks in front compute M = |S|^2 / (Ea Eb + guard)). When M reaches `threshold` the next 144 windows are collected; the plateau (the windows with M >= 24/32 of the largest)
      gives the start of the STS: s0 = window start + (first + last + 1) // 2 - 32. The carrier offset is the coarse one from the angle of S over the plateau (lag 16, unambiguous to +-120 kHz) plus the fine one from the two training symbols
      T1 and T2 (64 samples apart, the windows start at s0 + 154 and s0 + 218), which must repeat (|P|^2 >= E1 E2 / 2) or the frame is a false detection and is dropped.
      Outputs (one value per input sample): 0: the carrier offset in the unit of the stock Schmidl-and-Cox block (the stock oscillator turns by -2/N x this per sample), switched to the new value `delay` - 38 samples after s0 (the samples
      reach the oscillator `delay` samples late, through a Delay block); 1: the trigger of the stock Header/Payload Demux, a 1 at s0 + 122 + `delay` (the demux then skips the 16 samples of its guard interval, takes the two header symbols
      at s0 + 138 and s0 + 218 and the data symbols from s0 + 298, as the FPGA receiver does).
      It runs in the Python interpreter that the other Python blocks of the flowgraph share, at 3.84 million samples per second, so it is written to make as few NumPy calls as possible: GNU Radio keeps the last 1024 input samples for it (the history), it
      looks at M only when a frame is not being processed, and it writes its two outputs once per call. `found` and `rejected` count the frames."""
      import numpy as np
      from gnuradio import gr

      N, FS, HIST = 64, 3.84e6, 1024


      class blk(gr.sync_block):
          def __init__(self, threshold=0.65, delay=384):
              gr.sync_block.__init__(self, name="STS frame synchroniser", in_sig=[np.complex64, np.float32, np.complex64], out_sig=[np.float32, np.uint8])
              self.set_history(HIST)
              self.threshold, self.delay = threshold, delay
              self.scan = 0                                                       # absolute index of the first window not yet looked at
              self.stage = 0; self.m0 = 0; self.s0 = 0; self.fc = 0.0              # 0: searching, 1: collecting the windows, 2: waiting for the training symbols
              self.events = []                                                     # (absolute output index, kind, value): kind 0 = set the carrier, 1 = trigger
              self.cfo = 0.0; self.found = 0; self.rejected = 0

          def set_threshold(self, t): self.threshold = float(t)

          def _step(self, x, M, S, base, end):
              """x, M, S: the input arrays, element i has the absolute index base + i; end = the absolute index after the last one"""
              while True:
                  if self.stage == 0:
                      lo = max(self.scan, base) - base
                      if lo >= len(M): self.scan = end; return
                      idx = np.flatnonzero(M[lo:] >= self.threshold)
                      if len(idx) == 0: self.scan = end; return
                      self.m0 = base + lo + int(idx[0]); self.stage = 1
                  if self.stage == 1:
                      a = self.m0 - base
                      if a < 0: self.rejected += 1; self.scan = self.m0 + 144; self.stage = 0; continue
                      if a + 144 > len(M): return
                      seg = M[a:a + 144]; pk = float(seg.max()); pl = np.flatnonzero(seg >= pk * 24 / 32); first, last = int(pl[0]), int(pl[-1])
                      self.s0 = self.m0 - 63 + ((first + last + 1) >> 1) - 32
                      self.fc = float(np.angle(np.sum(S[a + first:a + last + 1])) / (2 * np.pi * 16 / FS))
                      self.stage = 2
                  if self.stage == 2:
                      i1, i2 = self.s0 + 154 - base, self.s0 + 218 - base
                      if i1 < 0: self.rejected += 1; self.scan = self.m0 + 144; self.stage = 0; continue
                      if i2 + N > len(x): return
                      rot = np.exp(-2j * np.pi * self.fc / FS * (np.arange(N) + 154))
                      a1 = x[i1:i1 + N] * rot; b1 = x[i2:i2 + N] * rot * np.exp(-2j * np.pi * self.fc / FS * 64)
                      P = np.sum(b1 * np.conj(a1)); e1 = float(np.sum(np.abs(a1) ** 2)); e2 = float(np.sum(np.abs(b1) ** 2))
                      if 2 * abs(P) ** 2 >= e1 * e2:
                          ff = float(np.angle(P)) / (2 * np.pi * 64 / FS); f = self.fc + ff; val = np.pi * N * f / FS
                          self.events.append((self.s0 + self.delay - 38, 0, val)); self.events.append((self.s0 + 122 + self.delay, 1, 0.0)); self.found += 1
                      else: self.rejected += 1
                      self.scan = self.m0 + 144; self.stage = 0; continue

          def work(self, input_items, output_items):
              x, M, S = input_items; out_cfo, out_trg = output_items; n = len(out_cfo)
              end = self.nitems_read(0) + n; base = end - len(x)                                        # absolute index of x[0] (the history comes first)
              self._step(x, M, S, base, end)
              lo = end - n
              out_trg[:] = 0
              if not self.events: out_cfo[:] = self.cfo
              else:
                  pos = 0
                  for ev in sorted(self.events):
                      if ev[0] >= end: break
                      i = max(ev[0] - lo, 0)
                      if ev[1] == 0: out_cfo[pos:i] = self.cfo; pos = i; self.cfo = ev[2]
                      else: out_trg[i] = 1
                  out_cfo[pos:] = self.cfo
                  self.events = [e for e in self.events if e[0] >= end]
              return n
    threshold: threshold
    delay: sync_delay
    minoutbuf: '262144'
    comment: 'THE ONE BLOCK THAT IS NOT STOCK in the front end: the stock Schmidl-and-Cox block needs a symbol of two equal halves of 32 samples; the 128-sample STS repeats every 16. This block finds the plateau of M, takes the start of the STS from it, measures the carrier (coarse from the angle of S, fine from the two training symbols) and gives the stock chain what ofdm_sync_sc_cfb gives it: the carrier offset (output 0) and the trigger of the Header/Payload Demux (output 1)'
  states: {}
- name: number_fnd
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: tabs@2:1,0,1,1
    label1: '"found"'
    min: '0'
    name: '"frames found per frame period (1 = every frame is found)"'
    type: float
    update_time: '0.25'
  states: {}
- name: trg_sum
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '3840'
    comment: 'STOCK: sums 3840 samples (one frame period): 1 = one trigger per frame period, i.e. the frame was found'
  states: {}
- name: check_n
  id: variable
  parameters:
    value: '8'
    comment: the error counter (Python) checks 1 frame in check_n; the Python blocks that run once per frame at 1000 frames per second keep the interpreter busy, and the flowgraph could not follow the B210 (overflows of the sample stream). The decisions of every frame are made by the stock blocks anyway
  states: {}
- name: keep_chk
  id: blocks_keep_m_in_n
  parameters:
    type: byte
    m: '1056'
    n: 1056 * check_n
    offset: '0'
    comment: 'STOCK: of every check_n frames (1056 symbols each) one goes to the error counter'
  states: {}
- name: pilot_eq
  id: epy_block
  parameters:
    smooth: '1'
    _source_code: |
      """Pilot equalizer: the equalizer of the P501 OFDM receivers (the same method as `ofdm_model.receive`) in place of the stock Frame Equalizer, which updates its channel taps from its own decisions: a wrong decision then corrupts
      the tap of its subcarrier for the symbols that follow (on a recording of the B210 with the P501 transmitting 4.7e-4 symbol errors, against none with the method of this block).
      Input: the FFT of the data symbols (64 values per symbol, DC in the middle) of the Header/Payload Demux, 44 symbols per frame; the first symbol of a frame carries the tag ofdm_sync_chan_taps (the channel estimate of the stock
      channel estimator, from the first training symbol). The taps are NOT updated within the frame. For every symbol:
        1. Z[k] = Y[k] / H[k] on the 24 data subcarriers and the 4 pilots (k = -11, -4, 4, 11)
        2. the pilots must be PIL_V x polarity of the symbol (QPSK, PRBS-7 of IEEE 802.11): mean of Z[pilot] conj(reference) over the 4 pilots = the common complex gain g of the symbol (carrier residue and gain), and with `slope` 1 the straight
           line of its phase against k is a timing drift; g (and the slope) are averaged over `smooth` symbols (centred; 1 = none)
        3. the data are divided by g (and turned back by the slope).
      Outputs: 0: the decided points (the nearest of the 16 points, 24 per symbol: the stock slicer after this block gives the index 0 .. 15); 1: the 24 soft values per symbol, for the plot; 2: the error vector magnitude in dB,
      measured against the PRBS-15 payload that the transmitter sends, as a running average over about 30 frames (frames with an error above -6 dB, wrong cuts or the start-up, are not counted).
      All the arithmetic of a frame is done in a few NumPy calls on all the symbols at once, because the Python interpreter is shared with the other Python blocks of the flowgraph and 1000 frames per second are to be done."""
      import numpy as np
      import pmt
      from gnuradio import gr

      L_SYM = 44
      KP = np.array([-11, -4, 4, 11]); KD = np.array([k for k in range(-14, 15) if k != 0 and k not in (-11, -4, 4, 11)])
      IP, ID = 32 + KP, 32 + KD
      PIL_V = np.array([1 + 1j, 1 - 1j, -1 + 1j, -1 - 1j]) / np.sqrt(2)
      POL = np.array([-1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, 1, -1, ], float)
      REF_P = PIL_V[None, :] * POL[:, None]
      LV = np.array([-3, -1, 1, 3]) / np.sqrt(10)
      GRAY = np.array([-3, -1, 3, 1]) / np.sqrt(10)


      def prbs15_symbols(n):
          s, bits = 0x7FFF, []
          for _ in range(4 * n):
              bits.append((s >> 14) & 1); s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)
          b = np.array(bits, int).reshape(n, 4)
          return b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]


      IDX = prbs15_symbols(L_SYM * 24)
      REF_D = (GRAY[IDX >> 2] + 1j * GRAY[IDX & 3]).reshape(L_SYM, 24)
      P_REF = np.mean(np.abs(REF_D) ** 2)


      def smoothing_matrix(n, L=L_SYM):
          if n <= 1: return np.eye(L)
          w = np.ones(n); M = np.zeros((L, L))
          for j in range(L): M[:, j] = np.convolve(np.eye(L)[j], w, "same")
          return M / M.sum(axis=1, keepdims=True)


      S10 = np.sqrt(10)
      LV32 = LV.astype(np.float32)
      REF_PC = np.conj(REF_P).astype(np.complex64)                  # [symbol, pilot]


      def decide(z):
          """the nearest of the 16 points: the levels -3 -1 1 3 (over sqrt 10) on I and on Q"""
          i = np.clip(np.floor(z.real * (S10 / 2) + 2), 0, 3).astype(np.intp); q = np.clip(np.floor(z.imag * (S10 / 2) + 2), 0, 3).astype(np.intp)
          return LV32[i] + 1j * LV32[q]


      class blk(gr.sync_block):
          def __init__(self, smooth=1, slope=0, frames=16, evm_every=8):
              gr.sync_block.__init__(self, name="Pilot equalizer (no decision feedback)", in_sig=[(np.complex64, 64)], out_sig=[(np.complex64, 24), (np.complex64, 24), np.float32])
              self.smooth = smooth; self.slope = slope; self.evm_every = max(int(evm_every), 1)
              self.set_output_multiple(L_SYM * max(int(frames), 1))                       # many frames per call: the NumPy calls cost the same for 1 frame as for 16
              self.pw = None; self.key = pmt.intern("ofdm_sync_chan_taps")

          @property
          def smooth(self):
              return self._smooth

          @smooth.setter
          def smooth(self, v):
              self._smooth = int(v); self.M = smoothing_matrix(self._smooth)

          def work(self, input_items, output_items):
              y = input_items[0]; dec, soft, ev = output_items
              n0 = self.nitems_read(0); nf = len(y) // L_SYM
              Hi = np.zeros((nf, 64), np.complex64); ok = np.zeros(nf, bool)
              for t in self.get_tags_in_window(0, 0, nf * L_SYM, self.key):
                  f, r = divmod(t.offset - n0, L_SYM)
                  if r == 0 and f < nf: Hi[f] = pmt.c32vector_elements(t.value); ok[f] = True
              with np.errstate(divide="ignore", invalid="ignore"):
                  Hi = 1 / Hi                                                              # the taps are divided out: Y x (1 / H)
              ok &= np.isfinite(Hi[:, IP]).all(axis=1) & np.isfinite(Hi[:, ID]).all(axis=1)
              Hi[~ok] = 0
              Y = y[:nf * L_SYM].reshape(nf, L_SYM, 64)
              Zp = Y[:, :, IP] * Hi[:, None, IP]
              if self.slope:                                                               # the straight line of the pilot phases against k: a timing drift
                  P = Zp * REF_PC[None]; ph = np.unwrap(np.angle(P), axis=2)
                  sl = np.einsum("ij,fj->fi", self.M, (ph @ KP) / np.sum(KP ** 2)).astype(np.float32)
                  Zp = Zp * np.exp(-1j * sl[:, :, None] * KP[None, None, :]).astype(np.complex64)
              g = np.einsum("fsp,sp->fs", Zp, REF_PC) / 4                                  # the common complex gain of the symbol: mean of Z[pilot] conj(reference)
              if self._smooth > 1: g = np.einsum("ij,fj->fi", self.M, g)
              gi = 1 / np.where(g == 0, 1, g)
              Zd = Y[:, :, ID] * Hi[:, None, ID]
              if self.slope: Zd = Zd * np.exp(-1j * sl[:, :, None] * KD[None, None, :]).astype(np.complex64)
              out = Zd * gi[:, :, None].astype(np.complex64)
              dec[:nf * L_SYM] = decide(out).reshape(-1, 24); soft[:nf * L_SYM] = out.reshape(-1, 24)
              for f in range(0, nf, self.evm_every):                                       # the EVM of 1 frame in evm_every
                  if ok[f]:
                      e = np.mean(np.abs(out[f] - REF_D) ** 2) / P_REF
                      if e < 0.25: self.pw = e if self.pw is None else 0.9 * self.pw + 0.1 * e
              ev[:nf * L_SYM] = 10 * np.log10(max(self.pw, 1e-12)) if self.pw is not None else 0.0
              return nf * L_SYM
    comment: 'CUSTOM BLOCK (in place of the stock Frame Equalizer): the channel from the training symbol, the common phase and gain of every symbol from the 4 pilots, no update from the decisions; outputs the decided points, the soft values and the EVM'
    slope: '0'
    frames: '16'
    evm_every: '8'
  states: {}
- name: v2s_dec
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '24'
    comment: the decided points of 24 per symbol in a row
  states: {}

connections:
- [uhd_usrp_source_0, '0', rx_in, '0']
- [file_source_0, '0', throttle_0, '0']
- [throttle_0, '0', rx_in, '0']
- [rx_in, '0', dc_iir, '0']
- [rx_in, '0', dc_sub, '0']
- [dc_iir, '0', dc_sub, '1']
- [dc_sub, '0', x_mag, '0']
- [rx_in, '0', freq_sink_rx, '0']
- [x_mag, '0', time_sink_rx, '0']
- [x_mag2, '0', x_scale, '0']
- [dc_sub, '0', x_mag2, '0']
- [x_scale, '0', time_sink_det, '0']
- [detect_f, '0', time_sink_det, '1']
- [cfo_hz_raw, '0', time_sink_cfo, '0']
- [dc_sub, '0', sym_delay, '0']
- [sym_delay, '0', rot, '0']
- [osc, '0', rot, '1']
- [rot, '0', hpd, '0']
- [hpd, '0', fft_hdr, '0']
- [fft_hdr, '0', chanest, '0']
- [chanest, '0', hdr, '0']
- [hdr, header_data, hpd, header_data]
- [hdr, '0', h_mag, '0']
- [hdr, '0', h_arg, '0']
- [h_mag, '0', vec_hmag, '0']
- [h_arg, '0', vec_harg, '0']
- [hpd, '1', fft_pay, '0']
- [fft_pay, '0', fft_scale, '0']
- [fft_scale, '0', fft_mag, '0']
- [fft_mag, '0', fft_avg, '0']
- [fft_avg, '0', vec_fft, '0']
- [fft_scale, '0', v2s64, '0']
- [v2s64, '0', keep29, '0']
- [keep29, '0', const_raw, '0']
- [v2s_soft, '0', keep_soft, '0']
- [keep_soft, '0', const_soft, '0']
- [keep_evm, '0', number_evm, '0']
- [dc_sub, '0', sc_delay, '0']
- [sc_delay, '0', sc_conj, '0']
- [dc_sub, '0', sc_mult, '0']
- [sc_conj, '0', sc_mult, '1']
- [sc_mult, '0', sc_avg, '0']
- [sc_avg, '0', sc_mag2, '0']
- [dc_sub, '0', en_mag2, '0']
- [en_mag2, '0', en_avg, '0']
- [en_avg, '0', en_mult, '1']
- [en_avg, '0', en_delay, '0']
- [en_delay, '0', en_mult, '0']
- [en_mag2, '0', guard_avg, '0']
- [guard_avg, '0', guard_sq, '0']
- [guard_avg, '0', guard_sq, '1']
- [guard_sq, '0', guard_k, '0']
- [en_mult, '0', guard_add, '0']
- [guard_k, '0', guard_add, '1']
- [guard_add, '0', en_eps, '0']
- [sc_mag2, '0', sc_div, '0']
- [en_eps, '0', sc_div, '1']
- [sc_div, '0', time_sink_m, '0']
- [thr_src, '0', time_sink_m, '1']
- [dc_sub, '0', sts_sync, '0']
- [sc_div, '0', sts_sync, '1']
- [sc_avg, '0', sts_sync, '2']
- [sts_sync, '1', detect_f, '0']
- [sts_sync, '0', cfo_hz_raw, '0']
- [sts_sync, '0', osc, '0']
- [sts_sync, '1', hpd, '1']
- [counter, '0', number_ser, '0']
- [counter, '1', number_err, '0']
- [counter, '2', number_frames, '0']
- [counter, '3', number_recent, '0']
- [detect_f, '0', trg_sum, '0']
- [trg_sum, '0', number_fnd, '0']
- [dec, '0', keep_chk, '0']
- [keep_chk, '0', counter, '0']
- [fft_pay, '0', pilot_eq, '0']
- [pilot_eq, '0', v2s_dec, '0']
- [v2s_dec, '0', const_eq, '0']
- [v2s_dec, '0', dec, '0']
- [pilot_eq, '1', v2s_soft, '0']
- [pilot_eq, '2', keep_evm, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
