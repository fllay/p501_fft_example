options:
  parameters:
    author: p501_fft_example
    description: The B210 transmits the OFDM frames (S&C symbol, 2 training symbols, 44 data symbols of 24 16-QAM subcarriers and 4 QPSK pilots, 1 ms) at 850 MHz, 3.84 MS/s; the P501 overlay p501_ofdm_rx_sc decodes them.
    generate_options: qt_gui
    id: ofdm_b210_frame_tx
    output_language: python
    title: 'B210 transmitter: OFDM frames (Schmidl-and-Cox preamble, 16-QAM data) for the P501''s FPGA receiver'
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    comment: 'carrier: the P501 receiver (notebook P501_OFDM_Live, p501_ofdm_b210.py) must use the same LO; 850 MHz gave a strong signal in our lab, 915 MHz a weak one. Check the rules where you are before transmitting'
    value: 850e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MS/s: the P501''s sample rate; N = 64 subcarriers of 60 kHz'
    value: '3840000'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: 'OFDM peaks are 3.4 x the RMS: 0.25 gives peaks of 0.85 of full scale; 0.29 is the limit'
    gui_hint: 1,0,1,4
    label: TX digital amplitude (RMS of the active part)
    start: '0'
    step: '0.01'
    stop: '0.29'
    value: '0.25'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'very low power: antennas a few centimetres apart. The B210 compresses above about 78 dB: 79 dB gave a symbol error rate of 1e-4 at an SNR of 25 dB, 85 dB 6e-3. Lower it to see where the decoding stops'
    gui_hint: 0,1,1,3
    label: B210 TX gain (dB)
    start: '0'
    step: '1'
    stop: '86'
    value: '79'
  states: {}
- name: tx_on
  id: variable_qtgui_chooser
  parameters:
    comment: OFF at start. Switch ON when the P501 is ready to receive.
    gui_hint: 0,0,1,1
    label: Transmit (B210 TX/RX port)
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp*tx_on
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport os, sys\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"The OFDM frames as a periodic complex stream at 3.84 MS/s: S&C symbol | T1 | T2 | 44 data symbols (24 16-QAM subcarriers + 4 QPSK pilots, 16-sample prefix) | 80 idle\n    = 3840 samples = 1 ms, the frame of the P501 receiver (tutorial/ofdm/PLAN_OFDM.md). The samples come from ofdm_frame.npy (made by tutorial/ofdm/make_ofdm_frame.py) or, if the file is not found,\n    from ofdm_model.tx_frame (the repository's model; run from the repository root or from tutorial/ofdm). Unit rms over the active part (3760 samples); fill_idle puts noise of the same rms in the\n    idle slot (it is empty by default: the receiver's detector has a guard for that).\"\"\"\n\n    def __init__(self, frame_file=\"ofdm_frame.npy\", fill_idle=False):\n        gr.sync_block.__init__(self, name=\"OFDM frames\", in_sig=None, out_sig=[np.complex64])\n        x = None\n        for f in (frame_file, os.path.join(\"tutorial\", \"ofdm\", frame_file), os.path.join(\"..\", \"..\", \"tutorial\", \"ofdm\", frame_file)):\n            if os.path.exists(f):\n                x = np.load(f).astype(complex); break\n        if x is None:\n            for d in (\".\", os.path.join(\"tutorial\", \"ofdm\"), os.path.join(\"..\", \"..\", \"tutorial\", \"ofdm\")):\n                if os.path.exists(os.path.join(d, \"ofdm_model.py\")):\n                    sys.path.insert(0, os.path.abspath(d)); import ofdm_model\n                    x = ofdm_model.tx_frame(preamble=\"scu\")[0]; break\n        if x is None or len(x) != 3840:\n            raise RuntimeError(\"ofdm_frame.npy (3840 samples) not found: run tutorial/ofdm/make_ofdm_frame.py and start from that folder\")\n        x = x / np.sqrt(np.mean(np.abs(x[:3760]) ** 2))\n        if fill_idle:\n            r = np.random.RandomState(1)\n            x[3760:] = np.clip(r.randn(80), -2.5, 2.5) / np.sqrt(2) + 1j * np.clip(r.randn(80), -2.5, 2.5) / np.sqrt(2)\n        self.data = x.astype(np.complex64)\n        self.pos = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        idx = (self.pos + np.arange(n)) % len(self.data)\n        out[:] = self.data[idx]\n        self.pos = (self.pos + n) % len(self.data)\n        return n\n"
    frame_file: '"ofdm_frame.npy"'
    fill_idle: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,5,4
    label1: TX
    legend: 'False'
    name: '"spectrum of the transmitted signal"'
    type: complex
    update_time: '0.1'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,0,3,4
    label1: '|x|'
    legend: 'False'
    name: '"envelope of the transmitted signal (two frames of 3840 samples = 1 ms each; the idle slot of 80 samples is at the end of each)"'
    size: '7680'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '1.0'
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    comment: the B210 transmitter (TX/RX port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
