options:
  parameters:
    author: p501_fft_example
    description: The B210 transmits the 16-QAM frames (CP | ZC word | 14 x (63 symbols + pilot), PRBS-15 payload) at 915 MHz, 3.84 MSPS; the P501 overlay p501_qam16_trx decodes them.
    generate_options: qt_gui
    id: qam16_b210_frame_tx
    output_language: python
    title: 'B210 transmitter: 16-QAM frames with a Zadoff-Chu word for the P501''s FPGA receiver'
  states: {}

blocks:
- name: const_dqpsk
  id: variable
  parameters:
    comment: 'differential QPSK: rotation-proof, the same as the FPGA'
    value: digital.constellation_dqpsk().base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: root-raised-cosine roll-off
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: carrier; check the rules where you are before transmitting
    value: 850e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MSPS: the P501''s sample rate; 960 ksym/s at 4 samples per symbol'
    value: '3840000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: 'the peak is 1.8 x the RMS: 0.35 gives 0.64 of full scale; 0.18 is 6 dB weaker'
    gui_hint: 1,0,1,4
    label: TX digital amplitude (RMS)
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.35'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'very low power: antennas a few centimetres apart; at the digital level 0.35 the P501 decodes without an error from 80 to 86 dB (a strong link); lower it to see where the decoding stops'
    gui_hint: 0,1,1,3
    label: B210 TX gain (dB)
    start: '0'
    step: '1'
    stop: '86'
    value: '80'
  states: {}
- name: tx_on
  id: variable_qtgui_chooser
  parameters:
    comment: OFF at start. Switch ON when the P501 is ready to receive.
    gui_hint: 0,0,1,1
    label: Transmit (B210 TX/RX port)
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp*tx_on
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"The 16-QAM frames as a periodic complex stream at 4 samples per symbol and unit RMS: CP 8 | ZC word 63 (root 1) | 14 x (63 16-QAM symbols + 1 pilot), 967 symbols = 3868 samples per frame;\n    Gray levels -3 -1 3 1 (00 01 10 11) / sqrt(10), pilots +-1 (1 1 -1 1 -1 -1 1 1 1 -1 -1 1 -1 1), the payload = PRBS-15 (x^15 + x^14 + 1, seed 0x7FFF, 4 bits per symbol, I = the first two bits)\n    restarted in every frame; root-raised-cosine 0.35, 45 taps. The period is made from the middle frame of five, so that the repetition is seamless.\"\"\"\n\n    def __init__(self):\n        gr.sync_block.__init__(self, name=\"16-QAM frames\", in_sig=None, out_sig=[np.complex64])\n        N, NCP, NB, ND, SPS, BETA = 63, 8, 14, 63, 4, 0.35\n        n = np.arange(N)\n        zc = np.exp(-1j * np.pi * n * (n + 1) / N)\n        s, bits = 0x7FFF, []\n        for i in range(4 * NB * ND):\n            bits.append((s >> 14) & 1)\n            s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)\n        b = np.array(bits, dtype=int).reshape(NB * ND, 4)\n        idx = b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]\n        gray = np.array([-3, -1, 3, 1]) / np.sqrt(10.0)\n        data = (gray[idx >> 2] + 1j * gray[idx & 3]).reshape(NB, ND)\n        pil = np.array([1, 1, -1, 1, -1, -1, 1, 1, 1, -1, -1, 1, -1, 1], dtype=float)\n        frame = np.concatenate([zc[-NCP:], zc, np.concatenate([data, pil[:, None].astype(complex)], axis=1).reshape(-1)])\n        sym = np.tile(frame, 5)\n        k = (np.arange(11 * SPS + 1) - 5 * SPS) / SPS\n        h = np.zeros(len(k))\n        for i, t in enumerate(k):\n            if abs(t) < 1e-12: h[i] = 1 + BETA * (4 / np.pi - 1)\n            elif abs(abs(t) - 1 / (4 * BETA)) < 1e-9: h[i] = BETA / np.sqrt(2) * ((1 + 2 / np.pi) * np.sin(np.pi / (4 * BETA)) + (1 - 2 / np.pi) * np.cos(np.pi / (4 * BETA)))\n            else: h[i] = (np.sin(np.pi * t * (1 - BETA)) + 4 * BETA * t * np.cos(np.pi * t * (1 + BETA))) / (np.pi * t * (1 - (4 * BETA * t) ** 2))\n        up = np.zeros(len(sym) * SPS, dtype=complex); up[::SPS] = sym\n        x = np.convolve(up, h)[len(h) // 2:len(h) // 2 + len(up)]\n        L = len(frame) * SPS\n        seg = x[2 * L:3 * L] / np.sqrt(np.mean(np.abs(x[L:4 * L]) ** 2))\n        self.data = seg.astype(np.complex64)\n        self.pos = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        idx = (self.pos + np.arange(n)) % len(self.data)\n        out[:] = self.data[idx]\n        self.pos = (self.pos + n) % len(self.data)\n        return n\n"
  states: {}
- name: import_digital
  id: import
  parameters:
    comment: only for the helper variable const_dqpsk of the common header
    imports: from gnuradio import digital
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,5,4
    label1: TX
    legend: 'False'
    name: '"spectrum of the transmitted signal"'
    type: complex
    update_time: '0.1'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,0,3,4
    label1: '|x|'
    legend: 'False'
    name: '"envelope of the transmitted signal (one frame = 3868 samples)"'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '0.8'
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    comment: the B210 transmitter (TX/RX port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
