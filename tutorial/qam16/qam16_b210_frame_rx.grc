options:
  parameters:
    author: p501_fft_example
    description: 'The B210 receives the 16-QAM frames of the P501''s FPGA transmitter at 915 MHz and decodes them (Zadoff-Chu frame sync, PLL, PRBS-15 check): constellation, symbol error rate, EVM.'
    generate_options: qt_gui
    id: qam16_b210_frame_rx
    output_language: python
    title: 'B210 receiver: 16-QAM frames of the P501''s FPGA transmitter, decoded with GNU Radio'
  states: {}

blocks:
- name: bw_div
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: 'Timing loop bandwidth: 2 pi / N'
    start: '100'
    step: '50'
    stop: '1600'
    value: '400'
  states: {}
- name: const_dqpsk
  id: variable
  parameters:
    comment: 'differential QPSK: rotation-proof, the same as the FPGA'
    value: digital.constellation_dqpsk().base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: root-raised-cosine roll-off
    value: '0.35'
  states: {}
- name: fll_div
  id: variable_qtgui_range
  parameters:
    comment: 'the FLL''s frequency noise decides how low the SNR can be: a narrower FLL (larger N) is quieter; it has to pull in the +9.6 kHz of the two radios'
    gui_hint: 1,2,1,2
    label: 'FLL bandwidth: 2 pi / N'
    start: '100'
    step: '100'
    stop: '6400'
    value: '1600'
  states: {}
- name: fll_on
  id: variable_qtgui_chooser
  parameters:
    comment: 'OFF: zero loop gain, the FLL passes the signal through'
    gui_hint: 2,0,1,1
    label: FLL band-edge
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    comment: carrier; check the rules where you are before transmitting
    value: 915e6
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: arms of the polyphase clock sync
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, 11*int(sps*nfilts))
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: raise it until the received spectrum is clearly above the noise; lower it if the constellation is squashed
    gui_hint: 0,0,1,4
    label: B210 RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MSPS: the P501''s sample rate; 960 ksym/s at 4 samples per symbol'
    value: '3840000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.06'
    comment: reference 0.947 = the mean magnitude of 16-QAM at unit RMS
    decay_rate: '1e-3'
    gain: '1'
    max_gain: '200'
    reference: '0.947'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '3'
    lo: '-3'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '3'
    lo: '-3'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: 2*3.14159265/fll_div*fll_on
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts//2
    loop_bw: 2*3.14159265/bw_div
    max_dev: '0.05'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """Streaming receiver of the 16-QAM / Zadoff-Chu frames for GNU Radio: the algorithm of framerx_hw.FrameRxHW (the float model of the FPGA receiver) as a class that takes the symbols (1 sample per symbol, after the matched filter
      and the timing recovery) in chunks of any size and keeps its state: SEARCH -> VERIFY -> LOCKED (word correlation with |C| / sum|x|, thresholds 0.6 / 0.45, window +-4, 3 misses), carrier frequency and phase from the two half-word correlations,
      the PLL (decision directed on the data, pilot weight 3, the known CP and word symbols in the loop, loop bandwidth 0.02), the payload checked against the PRBS-15 restarted in every frame.

          rx = StreamRx(); data, info = rx.push(x)         # data: the derotated, normalised data symbols of the frames completed by this chunk (882 per frame); info: one dict per frame
      It is self-contained (numpy only): the GNU Radio block (make_flowgraph_qam16.py) embeds this file. Tested against FrameRxHW with random chunk sizes (test_stream_rx.py)."""
      import math
      import numpy as np

      N_ZC, ROOT, N_CP, N_BLK, N_DATA = 63, 1, 8, 14, 63
      N_PAY = N_BLK * N_DATA
      BLK = N_DATA + 1
      PAY_LEN = N_BLK * BLK
      FRAME = N_CP + N_ZC + PAY_LEN
      S10 = math.sqrt(10.0)
      _n = np.arange(N_ZC)
      ZC = np.exp(-1j * np.pi * ROOT * _n * (_n + 1) / N_ZC)
      CP_REF = ZC[-N_CP:]
      PILOTS = [1.0, 1.0, -1.0, 1.0, -1.0, -1.0, 1.0, 1.0, 1.0, -1.0, -1.0, 1.0, -1.0, 1.0]
      LEVEL_IDX = {-3: 0, -1: 1, 1: 3, 3: 2}


      def _prbs15_indices():
          s, bits = 0x7FFF, []
          for i in range(4 * N_PAY):
              bits.append((s >> 14) & 1)
              s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)
          b = np.array(bits, dtype=int).reshape(N_PAY, 4)
          return b[:, 0] * 8 + b[:, 1] * 4 + b[:, 2] * 2 + b[:, 3]


      REF_IDX = _prbs15_indices()


      def _level(a):
          return -3 if a < -2 else (-1 if a < 0 else (1 if a < 2 else 3))


      def _amag(z):
          a, b = np.abs(z.real), np.abs(z.imag)
          return np.maximum(a, b) + 0.5 * np.minimum(a, b)


      class StreamRx:
          def __init__(self, loop_bw=0.02, thr_search=0.6, thr_lock=0.45, window=4, max_miss=3, tol_verify=3, pilot_weight=3.0, aided=True, amp_mode="word"):
              zeta = 0.7071
              den = 1 + 2 * zeta * loop_bw + loop_bw ** 2
              self.alpha, self.beta = 4 * zeta * loop_bw / den, 4 * loop_bw ** 2 / den
              self.thr_s, self.thr_l, self.win, self.max_miss, self.tolv = thr_search, thr_lock, window, max_miss, tol_verify
              self.pw, self.aided, self.amp_mode = pilot_weight, aided, amp_mode
              self.buf = np.zeros(0, dtype=complex)
              self.locked = False
              self.first = True
              self.nxt = 0                      # expected word start of the next frame, index in buf
              self.miss = 0
              self.theta = self.om = 0.0
              self.amp = 1.0
              self.frames = self.locks = self.hits = self.misses = self.lost = 0
              self.sym_err = self.sym_cnt = self.bit_err = self.bad_frames = 0
              self.evm_db = float("nan"); self.cfo = 0.0; self.lock_cfo = 0.0

          # ---------------------------------------------------------------- metric
          @staticmethod
          def _rho(x, idx):
              """rho = |C| / sum|x| (max + min/2 magnitudes) of the 63-symbol windows starting at idx (array)"""
              idx = np.asarray(idx)
              out = np.zeros(len(idx))
              for k, i in enumerate(idx):
                  w = x[i:i + N_ZC]
                  c = np.dot(w, np.conj(ZC))
                  e = _amag(w).sum()
                  out[k] = _amag(np.array([c]))[0] / e if e > 0 else 0.0
              return out

          @staticmethod
          def _rho_all(x):
              c = np.correlate(x, ZC, "valid")
              e = np.concatenate([[0.0], np.cumsum(_amag(x))]); s1 = e[N_ZC:] - e[:-N_ZC]
              m = _amag(c)
              return m / (s1 + 1e-20), m

          # ---------------------------------------------------------------- carrier from the word
          @staticmethod
          def _word(w):
              z = w * np.conj(ZC)
              c1, c2 = z[:31].sum(), z[32:].sum()
              p = c2 * np.conj(c1)
              return math.atan2(p.imag, p.real) / 32.0, c1, c2

          @staticmethod
          def _phase(c1, c2, om):
              r = c1 * np.exp(1j * 16 * om) + c2 * np.exp(-1j * 16 * om)
              return math.atan2(r.imag, r.real) + 32 * om, abs(r) / 62.0

          def _known(self, theta, om, seg, ref):
              if not self.aided:
                  return theta + om * len(seg), om
              al, be = self.alpha, self.beta
              for v, rf in zip(seg.tolist(), ref.tolist()):
                  cs, sn = math.cos(theta), math.sin(theta)
                  zr, zi = v.real * cs + v.imag * sn, v.imag * cs - v.real * sn
                  e = zi * rf.real - zr * rf.imag
                  om += be * e; theta += om + al * e
              return theta, om

          def _pll(self, pay, theta, om):
              al, be, pw = self.alpha, self.beta, self.pw
              data, idx = [], []
              err2 = ref2 = 0.0
              pr, pi_ = pay.real.tolist(), pay.imag.tolist()
              for i in range(PAY_LEN):
                  cs, sn = math.cos(theta), math.sin(theta)
                  yr, yi = pr[i], pi_[i]
                  zr, zi = yr * cs + yi * sn, yi * cs - yr * sn
                  if i % BLK == BLK - 1:
                      rr, ri, w = PILOTS[i // BLK], 0.0, pw
                  else:
                      lr, lq = _level(zr * S10), _level(zi * S10)
                      rr, ri, w = lr / S10, lq / S10, 1.0
                      data.append(complex(zr, zi)); idx.append(4 * LEVEL_IDX[lr] + LEVEL_IDX[lq])
                      err2 += (zr - rr) ** 2 + (zi - ri) ** 2; ref2 += rr * rr + ri * ri
                  e = (zi * rr - zr * ri) * w
                  om += be * e; theta += om + al * e
              return theta, om, np.array(data, dtype=complex), idx, 10 * math.log10(max(err2, 1e-12) / max(ref2, 1e-12))

          # ---------------------------------------------------------------- streaming
          def push(self, x):
              self.buf = np.concatenate([self.buf, np.asarray(x, dtype=complex)])
              data, info = [], []
              while True:
                  if self.locked:
                      if not self._locked_step(data, info): break
                  elif not self._search(): break
              return (np.concatenate(data) if data else np.zeros(0, dtype=complex)), info

          def _search(self):
              L = len(self.buf)
              if L < N_ZC + 2:
                  return False
              rho, m = self._rho_all(self.buf)
              ok = np.zeros(len(m), dtype=bool)
              ok[1:-1] = (rho[1:-1] >= self.thr_s) & (m[1:-1] >= m[:-2]) & (m[1:-1] > m[2:])
              for p in np.nonzero(ok)[0]:
                  hi = p + FRAME + self.tolv
                  if hi >= len(rho):                                  # cannot verify yet: wait, keeping the data from the candidate on
                      self.buf = self.buf[p:]
                      return False
                  if rho[p + FRAME - self.tolv:hi + 1].max() >= self.thr_l:
                      self.buf = self.buf[p:]
                      self.locked, self.first, self.miss, self.nxt = True, True, 0, 0
                      self.locks += 1
                      return True
              self.buf = self.buf[max(len(self.buf) - (N_ZC + 1), 0):]       # nothing: keep the tail (a window and the neighbours of a peak)
              return False

          def _locked_step(self, data, info):
              L = len(self.buf)
              e, W = self.nxt, self.win
              if not self.first and L < e + W + N_ZC + PAY_LEN:
                  return False
              if self.first and L < e + N_ZC + PAY_LEN:
                  return False
              if self.first:
                  s = e; hit = True
              else:
                  lo, hi = e - W, e + W
                  rho = self._rho(self.buf, np.arange(lo, hi + 1))
                  j = int(np.argmax(rho))
                  if rho[j] >= self.thr_l:
                      s = lo + j; self.miss = 0; self.hits += 1; hit = True
                  else:
                      s = e; self.miss += 1; self.misses += 1; hit = False
                      if self.miss > self.max_miss:
                          self.locked = False; self.lost += 1; self.theta = self.om = 0.0
                          self.buf = self.buf[e + 1:]
                          return True
              w = self.buf[s:s + N_ZC]
              om_w, c1, c2 = self._word(w)
              if self.first:
                  self.om = om_w; self.lock_cfo = om_w
                  th0, h = self._phase(c1, c2, self.om)
                  self.amp = h if self.amp_mode == "word" else 1.0
                  self.theta = th0
              else:
                  a = max(self.amp, 1e-9)
                  self.theta, self.om = self._known(self.theta, self.om, self.buf[s - N_CP:s] / a, CP_REF)
                  self.theta, self.om = self._known(self.theta, self.om, w / a, ZC)
                  if self.amp_mode == "word":
                      _, h = self._phase(c1, c2, self.om); self.amp = 0.7 * self.amp + 0.3 * h
              pay = self.buf[s + N_ZC:s + N_ZC + PAY_LEN] / max(self.amp, 1e-9)
              self.theta, self.om, d, idx, self.evm_db = self._pll(pay, self.theta, self.om)
              ne = int(np.sum(np.asarray(idx) != REF_IDX)); xb = np.asarray(idx) ^ REF_IDX
              nb = int(sum(bin(int(v)).count("1") for v in xb[np.asarray(idx) != REF_IDX]))
              self.frames += 1; self.sym_err += ne; self.sym_cnt += N_PAY; self.bit_err += nb; self.bad_frames += int(ne > 0.2 * N_PAY)
              self.cfo = self.om
              data.append(d)
              info.append(dict(frame=self.frames, sym_err=ne, bit_err=nb, evm_db=self.evm_db, hit=hit, start=s))
              self.first = False
              cut = s + FRAME - W - N_CP - 2                          # keep the CP before the next word and the window
              self.buf = self.buf[cut:]
              self.nxt = s + FRAME - cut
              return True


      from gnuradio import gr


      class blk(gr.basic_block):
          """16-QAM ZC receiver. Input: the symbols after the polyphase clock sync (1 sample per symbol, about unit RMS). Outputs: 0 the derotated data symbols of the frames found (882 per frame, for the constellation),
          1 symbol error rate since the lock (against the PRBS-15 of the frame), 2 EVM of the last frame (dB), 3 lock (1 / 0), 4 frames decoded, 5 carrier offset left for the PLL (Hz, at 960 ksym/s):
          one value per frame (one per call while not locked)."""

          def __init__(self, loop_bw=0.02, thr_search=0.6, thr_lock=0.45, pilot_weight=3.0, aided=True, symbol_rate=960000.0):
              gr.basic_block.__init__(self, name="16-QAM ZC receiver", in_sig=[np.complex64], out_sig=[np.complex64, np.float32, np.float32, np.float32, np.float32, np.float32])
              self.core = StreamRx(loop_bw=loop_bw, thr_search=thr_search, thr_lock=thr_lock, pilot_weight=pilot_weight, aided=bool(aided))
              self.rs = float(symbol_rate)
              self.pend = np.zeros(0, dtype=np.complex64)
              self.q = []
              self.ser = 0.5; self.evm_db = 0.0; self.locked = 0.0; self.frames = 0; self.cfo_hz = 0.0

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              x = input_items[0]
              self.consume(0, len(x))
              d, info = self.core.push(x)
              c = self.core
              if len(d): self.pend = np.concatenate([self.pend, d.astype(np.complex64)])
              self.ser = (c.sym_err / c.sym_cnt) if c.sym_cnt else 0.5
              self.evm_db = c.evm_db if c.evm_db == c.evm_db else 0.0
              self.locked = 1.0 if c.locked else 0.0
              self.frames = c.frames
              self.cfo_hz = c.om / (2 * np.pi) * self.rs
              row = (self.ser, self.evm_db, self.locked, float(c.frames), self.cfo_hz)
              self.q.extend([row] * max(len(info), 1))
              n0 = min(len(self.pend), len(output_items[0]))
              if n0:
                  output_items[0][:n0] = self.pend[:n0]; self.pend = self.pend[n0:]
              self.produce(0, n0)
              ns = min(len(self.q), len(output_items[1]))
              for k in range(5):
                  if ns: output_items[k + 1][:ns] = [r[k] for r in self.q[:ns]]
                  self.produce(k + 1, ns)
              self.q = self.q[ns:]
              return gr.WORK_CALLED_PRODUCE
    aided: 'True'
    loop_bw: '0.02'
    pilot_weight: '3.0'
    symbol_rate: samp_rate/sps
    thr_lock: '0.45'
    thr_search: '0.6'
  states: {}
- name: import_firdes
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,4,2
    label1: symbols
    legend: 'False'
    name: '"data symbols after the PLL"'
    size: '2048'
    type: complex
    update_time: '0.1'
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 8,0,4,6
    label1: B210 RX2
    legend: 'False'
    name: '"received spectrum"'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,2
    label1: SER
    min: '0'
    name: '"symbol error rate"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,2,1,2
    label1: EVM
    max: '0'
    min: '-40'
    name: '"EVM of the last frame (dB)"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,2,1,2
    label1: lock
    min: '0'
    name: '"lock (1 = locked on the frames)"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,4,1,2
    label1: frames
    max: '100000000'
    min: '0'
    name: '"frames decoded"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,4,1,2
    label1: offset
    max: '20000'
    min: '-20000'
    name: '"carrier offset left for the PLL (Hz)"'
    type: float
    update_time: '0.25'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: the B210 receiver (RX2 port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_complex_0, '0']
- [analog_rail_ff_1, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_float_0, '1', analog_rail_ff_1, '0']
- [blocks_float_to_complex_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '1', blocks_null_sink_0, '0']
- [digital_fll_band_edge_cc_0, '2', blocks_null_sink_1, '0']
- [digital_fll_band_edge_cc_0, '3', blocks_null_sink_2, '0']
- [digital_pfb_clock_sync_xxx_0, '0', epy_block_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', blocks_null_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '2', blocks_null_sink_4, '0']
- [digital_pfb_clock_sync_xxx_0, '3', blocks_null_sink_5, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0, '0']
- [epy_block_0, '2', qtgui_number_sink_1, '0']
- [epy_block_0, '3', qtgui_number_sink_2, '0']
- [epy_block_0, '4', qtgui_number_sink_3, '0']
- [epy_block_0, '5', qtgui_number_sink_4, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
