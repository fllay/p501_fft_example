options:
  parameters:
    category: Custom
    description: 16-QAM + Zadoff-Chu frame transmitter (USRP B210)
    generate_options: qt_gui
    id: qam16_zc_tx
    output_language: python
    title: 16-QAM + Zadoff-Chu frame transmitter (USRP B210)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: tx_taps
  id: variable_rrc_filter_taps
  parameters:
    gain: sps
    samp_rate: samp_rate
    sym_rate: symbol_rate
    alpha: excess_bw
    ntaps: 11*sps*1+1
    comment: Transmit pulse shape (RRC, 4 sps, span 11 symbols)
  states: {}
- name: tx_frames
  id: epy_block
  parameters:
    _source_code: |
      """16-QAM + Zadoff-Chu framed symbol source, 1 sample per symbol, unit average power.

      Frame (967 symbols) = [ CP 8 | ZC sync word 63 | 14 x ( 63 x 16-QAM data + 1 pilot ) ]
        CP    = last 8 symbols of the ZC word (cyclic prefix)
        ZC    = Zadoff-Chu, root 1, length 63, constant amplitude 1 (= average payload power)
        pilot = known +-1 symbol at the end of every 64-symbol block
      fixed_payload = True repeats the same payload (from seed) in every frame, so the receiver can count symbol errors.
      """
      import numpy as np
      from gnuradio import gr

      N_ZC, ROOT, N_CP, N_BLK, N_DATA = 63, 1, 8, 14, 63
      N_PAY = N_BLK * N_DATA                       # 882 data symbols per frame
      FRAME = N_CP + N_ZC + N_BLK * (N_DATA + 1)   # 967
      GRAY = np.array([-3, -1, 3, 1]) / np.sqrt(10.0)     # 2-bit index -> level (00,01,10,11)
      PILOTS = np.array([1, 1, -1, 1, -1, -1, 1, 1, 1, -1, -1, 1, -1, 1], dtype=float)


      def zc_word():
          n = np.arange(N_ZC)
          return np.exp(-1j * np.pi * ROOT * n * (n + 1) / N_ZC)


      def qam_from_index(k):
          k = np.asarray(k)
          return GRAY[k >> 2] + 1j * GRAY[k & 3]


      class blk(gr.sync_block):
          def __init__(self, seed=1, fixed_payload=False):
              gr.sync_block.__init__(self, name='16-QAM + ZC frame source', in_sig=None, out_sig=[np.complex64])
              self.rng = np.random.RandomState(int(seed))
              self.fixed = bool(fixed_payload)
              self.zc = zc_word()
              self.fixed_idx = np.random.RandomState(int(seed)).randint(0, 16, N_PAY)
              self.pending = np.zeros(0, dtype=np.complex64)

          def make_frame(self):
              idx = self.fixed_idx if self.fixed else self.rng.randint(0, 16, N_PAY)
              data = qam_from_index(idx).reshape(N_BLK, N_DATA)
              blocks = np.concatenate([data, PILOTS[:, None].astype(complex)], axis=1).reshape(-1)
              return np.concatenate([self.zc[-N_CP:], self.zc, blocks]).astype(np.complex64)

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              while len(self.pending) < n:
                  self.pending = np.concatenate([self.pending, self.make_frame()])
              out[:] = self.pending[:n]
              self.pending = self.pending[n:]
              return n
    seed: '1'
    fixed_payload: 'True'
    comment: '[CP 8 | ZC 63 | 14 x (63 x 16-QAM + 1 pilot)] = 967 symbols per frame, 1 sample/symbol'
  states: {}
- name: tx_rrc
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: sps
    taps: tx_taps
    comment: pulse shaping, 1 sps -> 4 sps
  states: {}
- name: tx_amp
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '0.3'
    comment: back-off / TX level
  states: {}
- name: usrp_tx
  id: uhd_usrp_sink
  parameters:
    type: fc32
    dev_args: '""'
    sync: sync
    clock_rate: '0.0'
    samp_rate: samp_rate
    center_freq0: freq
    gain0: '60'
    ant0: TX/RX
    norm_gain0: 'False'
    len_tag_name: ''
    comment: B210 TX/RX port. Use an attenuator/cable for a wired test!
  states: {}
- name: n1
  id: note
  parameters:
    note: 'Frame (967 symbols, 3.87 ms at 250 ksym/s): CP 8 | ZC 63 | 14 x (63 16-QAM + 1 pilot). Sync word and CP at average payload power.'
  states: {}

connections:
- [tx_frames, '0', tx_rrc, '0']
- [tx_rrc, '0', tx_amp, '0']
- [tx_amp, '0', usrp_tx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
