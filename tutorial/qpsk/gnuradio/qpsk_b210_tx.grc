options:
  parameters:
    author: p501_fft_example
    description: The B210 transmits PRBS-15 differential QPSK at 915 MHz, 3.84 MSPS; the P501 notebook receives it with its FPGA receiver.
    generate_options: qt_gui
    id: qpsk_b210_tx
    output_language: python
    title: 'B210 transmitter: PRBS-15 DQPSK for the P501''s FPGA receiver'
  states: {}

blocks:
- name: const_dqpsk
  id: variable
  parameters:
    comment: 'differential QPSK: rotation-proof, the same as the FPGA'
    value: digital.constellation_dqpsk().base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: root-raised-cosine roll-off
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: carrier; check the rules where you are before transmitting
    value: 915e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MSPS: the P501''s sample rate; 960 ksym/s at 4 samples per symbol'
    value: '3840000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: TX digital amplitude
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'very low power: antennas a few centimetres apart; 80 dB decodes cleanly at the P501, 70 is marginal, 60 does not lock'
    gui_hint: 0,1,1,3
    label: B210 TX gain (dB)
    start: '0'
    step: '1'
    stop: '80'
    value: '80'
  states: {}
- name: tx_on
  id: variable_qtgui_chooser
  parameters:
    comment: OFF at start. Switch ON when the P501 notebook is ready to receive.
    gui_hint: 0,0,1,1
    label: Transmit (B210 TX/RX port)
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp*tx_on
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const_dqpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"PRBS-15 (x^15 + x^14 + 1, seed 0x7FFF) as packed bytes, repeated: 8 periods = 262136 bits = 32767 whole bytes, so the repeat is seamless.\n    The bits are the ones that the FPGA transmitter (qpsk_tx.v) sends and that the FPGA receiver's self-synchronising checker expects.\"\"\"\n\n    def __init__(self):\n        gr.sync_block.__init__(self, name=\"PRBS-15 bytes\", in_sig=None, out_sig=[np.uint8])\n        s, bits = 0x7FFF, np.zeros(32767, dtype=np.uint8)\n        for i in range(32767):\n            bits[i] = (s >> 14) & 1\n            s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)\n        self.data = np.packbits(np.tile(bits, 8))\n        self.pos = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        idx = (self.pos + np.arange(n)) % len(self.data)\n        out[:] = self.data[idx]\n        self.pos = (self.pos + n) % len(self.data)\n        return n\n"
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,5,4
    label1: TX
    legend: 'False'
    name: '"spectrum of the transmitted signal"'
    type: complex
    update_time: '0.1'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    comment: the B210 transmitter (TX/RX port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
