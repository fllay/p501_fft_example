options:
  parameters:
    author: p501_fft_example
    description: 'The B210 receives the P501''s FPGA QPSK transmitter (PRBS-15) at 915 MHz and decodes it: constellation, spectrum and bit error rate.'
    generate_options: qt_gui
    id: qpsk_b210_rx
    output_language: python
    title: 'B210 receiver: the P501''s FPGA transmitter, decoded with GNU Radio'
  states: {}

blocks:
- name: bw_div
  id: variable_qtgui_range
  parameters:
    comment: wide (small N) pulls in fast and is noisy; narrow (large N) is quieter but may not pull in
    gui_hint: 1,0,1,4
    label: 'Loop bandwidth: 2 pi / N (FLL, timing, Costas)'
    start: '50'
    step: '10'
    stop: '1600'
    value: '400'
  states: {}
- name: const_dqpsk
  id: variable
  parameters:
    comment: 'differential QPSK: rotation-proof, the same as the FPGA'
    value: digital.constellation_dqpsk().base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: root-raised-cosine roll-off
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: carrier; check the rules where you are before transmitting
    value: 915e6
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: arms of the polyphase clock sync
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, 11*int(sps*nfilts))
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: raise it until the received spectrum is clearly above the noise; lower it if the constellation is squashed
    gui_hint: 0,0,1,4
    label: B210 RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MSPS: the P501''s sample rate; 960 ksym/s at 4 samples per symbol'
    value: '3840000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.06'
    decay_rate: '1e-3'
    gain: '1'
    max_gain: '200'
    reference: '1'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1.5'
    lo: '-1.5'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '1.5'
    lo: '-1.5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '19200'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_dqpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14159265/bw_div
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: 2*3.14159265/bw_div
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: inverse of the pre-differential code (it is its own inverse)
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts//2
    loop_bw: 2*3.14159265/bw_div
    max_dev: '0.05'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"Self-synchronising PRBS-15 checker, the same rule as the FPGA's: a[n] = a[n-15] ^ a[n-14]; a mismatch is counted when the received bit differs from\n    the prediction, and an isolated bit error gives 3 mismatches. Input: one bit per byte. Output: the bit error rate over about the last second\n    (mismatches / 3 / bits, exponentially weighted), one value per input bit; 0.17 means 'not locked' (random bits). A stream that is not half ones (for example\n    stuck at 0, which also satisfies the PRBS rule) is reported as 0.5.\"\"\"\n\n    def __init__(self, window_bits=1920000):\n        gr.sync_block.__init__(self, name=\"PRBS-15 BER\", in_sig=[np.uint8], out_sig=[np.float32])\n        self.window = float(window_bits)\n        self.hist = np.zeros(15, dtype=np.uint8)\n        self.filled = 0\n        self.m = 0.0\n        self.n = 0.0\n        self.o = 0.0\n        self.ber = 0.5\n\n    def work(self, input_items, output_items):\n        x = input_items[0] & 1\n        a = np.concatenate([self.hist, x])\n        if self.filled >= 15:\n            pred = a[:-15] ^ a[1:-14]\n            mism = float(np.count_nonzero(a[15:] != pred))\n            k = np.exp(-len(x) / self.window)\n            self.m = self.m * k + mism\n            self.n = self.n * k + len(x)\n            self.o = self.o * k + float(np.count_nonzero(x))\n            self.ber = 0.5 if abs(self.o / self.n - 0.5) > 0.15 else self.m / 3.0 / self.n\n        self.filled += len(x)\n        self.hist = a[-15:].copy()\n        output_items[0][:] = self.ber\n        return len(x)\n"
    window_bits: '480000'
  states: {}
- name: import_firdes
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,4,2
    label1: symbols
    legend: 'False'
    name: '"after the Costas loop"'
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 3,2,4,2
    label1: B210 RX2
    legend: 'False'
    name: '"received spectrum"'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    comment: 0.17 = not locked; 0.5 = no valid stream; 0 = locked and error-free
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,0,1,4
    label1: BER
    min: '0'
    name: '"PRBS-15 bit error rate"'
    type: float
    update_time: '0.25'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: the B210 receiver (RX2 port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_complex_0, '0']
- [analog_rail_ff_1, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_float_0, '1', analog_rail_ff_1, '0']
- [blocks_float_to_complex_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_number_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '1', blocks_null_sink_0, '0']
- [digital_fll_band_edge_cc_0, '2', blocks_null_sink_1, '0']
- [digital_fll_band_edge_cc_0, '3', blocks_null_sink_2, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', blocks_null_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '2', blocks_null_sink_4, '0']
- [digital_pfb_clock_sync_xxx_0, '3', blocks_null_sink_5, '0']
- [epy_block_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
