options:
  parameters:
    author: p501_fft_example
    description: The B210 transmits frames (64-symbol m-sequence preamble + payload) as differential QPSK at 915 MHz, 3.84 MSPS; the P501 overlay with the frame synchroniser finds them.
    generate_options: qt_gui
    id: qpsk_b210_frame_tx
    output_language: python
    title: 'B210 transmitter: m-sequence preamble + PRBS-15 payload frames (DQPSK) for the P501''s FPGA synchroniser'
  states: {}

blocks:
- name: const_dqpsk
  id: variable
  parameters:
    comment: 'differential QPSK: rotation-proof, the same as the FPGA'
    value: digital.constellation_dqpsk().base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: root-raised-cosine roll-off
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: carrier; check the rules where you are before transmitting
    value: 915e6
  states: {}
- name: payload_syms
  id: variable
  parameters:
    comment: payload symbols per frame (a multiple of 4); the frame is 64 + payload_syms symbols = 1024 symbols = 1.067 ms for 960; set the same FL, PL in the P501 notebook/driver
    value: '960'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MSPS: the P501''s sample rate; 960 ksym/s at 4 samples per symbol'
    value: '3840000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: TX digital amplitude
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'very low power: antennas a few centimetres apart; lower it to see where the synchroniser stops finding the preamble'
    gui_hint: 0,1,1,3
    label: B210 TX gain (dB)
    start: '0'
    step: '1'
    stop: '80'
    value: '80'
  states: {}
- name: tx_on
  id: variable_qtgui_chooser
  parameters:
    comment: OFF at start. Switch ON when the P501 is ready to receive.
    gui_hint: 0,0,1,1
    label: Transmit (B210 TX/RX port)
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp*tx_on
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const_dqpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"Frames as packed bytes, repeated: preamble (64 symbols: a reference symbol, then 63 phase STEPS = the chips of the m-sequence x^6 + x + 1: step 0 for chip +1, step 180 degrees for chip -1)\n    followed by payload_syms symbols of PRBS-15 (x^15 + x^14 + 1, seed 0x7FFF, restarted in every frame). The bits are before the differential encoder: chip +1 = chunk 00, chip -1 = chunk 11.\"\"\"\n\n    def __init__(self, payload_syms=960):\n        gr.sync_block.__init__(self, name=\"Frame bytes\", in_sig=None, out_sig=[np.uint8])\n        assert payload_syms % 4 == 0\n        a = [1, 0, 0, 0, 0, 0]\n        while len(a) < 63:\n            n = len(a) - 6\n            a.append(a[n + 1] ^ a[n])\n        pre = [0, 0]\n        for b in a:\n            pre += [1, 1] if b else [0, 0]\n        s, pay = 0x7FFF, []\n        for i in range(2 * int(payload_syms)):\n            pay.append((s >> 14) & 1)\n            s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)\n        self.data = np.packbits(np.array(pre + pay, dtype=np.uint8))\n        self.pos = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        idx = (self.pos + np.arange(n)) % len(self.data)\n        out[:] = self.data[idx]\n        self.pos = (self.pos + n) % len(self.data)\n        return n\n"
    payload_syms: payload_syms
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,5,4
    label1: TX
    legend: 'False'
    name: '"spectrum of the transmitted signal"'
    type: complex
    update_time: '0.1'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,0,3,4
    label1: '|x|'
    legend: 'False'
    name: '"envelope of the transmitted signal (the preamble is the first 64 symbols of each frame)"'
    size: '4096'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '0.5'
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    comment: the B210 transmitter (TX/RX port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
