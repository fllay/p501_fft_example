options:
  parameters:
    author: p501_fft_example
    description: 'The B210 receives the frames (m-sequence preamble + PRBS-15 payload) of the P501''s FPGA transmitter at 915 MHz and decodes them: constellation, spectrum, frames found and bit error rate of the payload.'
    generate_options: qt_gui
    id: qpsk_b210_frame_rx
    output_language: python
    title: 'B210 receiver: the frames of the P501''s FPGA transmitter, decoded with GNU Radio'
  states: {}

blocks:
- name: bw_div
  id: variable_qtgui_range
  parameters:
    comment: wide (small N) pulls in fast and is noisy; narrow (large N) is quieter but may not pull in
    gui_hint: 1,0,1,4
    label: 'Loop bandwidth: 2 pi / N (FLL, timing, Costas)'
    start: '50'
    step: '10'
    stop: '1600'
    value: '400'
  states: {}
- name: const_dqpsk
  id: variable
  parameters:
    comment: 'differential QPSK: rotation-proof, the same as the FPGA'
    value: digital.constellation_dqpsk().base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: root-raised-cosine roll-off
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: carrier; check the rules where you are before transmitting
    value: 915e6
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: arms of the polyphase clock sync
    value: '32'
  states: {}
- name: payload_syms
  id: variable
  parameters:
    comment: 'payload symbols per frame: the same as the P501''s start_frames(payload=...)'
    value: '960'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, 11*int(sps*nfilts))
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: raise it until the received spectrum is clearly above the noise; lower it if the constellation is squashed
    gui_hint: 0,0,1,4
    label: B210 RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: '3.84 MSPS: the P501''s sample rate; 960 ksym/s at 4 samples per symbol'
    value: '3840000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.06'
    decay_rate: '1e-3'
    gain: '1'
    max_gain: '200'
    reference: '1'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1.5'
    lo: '-1.5'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '1.5'
    lo: '-1.5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '19200'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '19200'
    type: float
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '19200'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_dqpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14159265/bw_div
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: 2*3.14159265/bw_div
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: inverse of the pre-differential code (it is its own inverse)
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts//2
    loop_bw: 2*3.14159265/bw_div
    max_dev: '0.05'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"Frame synchroniser and bit error counter of the frame receiver. Input: the decoded bits, one per byte, two per symbol (after the differential decoder and the symbol map: the bits that were sent).\n    A frame is 64 preamble symbols (128 bits: symbol 0 = 00, then 00 for a chip +1 and 11 for a chip -1 of the m-sequence x^6 + x + 1) followed by payload_syms symbols of PRBS-15 restarted in every frame.\n    The preamble is found by the Hamming distance of 128 bits to the known pattern (<= dmax; random data are at 64 +- 6, so a false match is practically impossible); then the 2 x payload_syms bits\n    that follow are compared with the PRBS-15 (a known pattern: every error counts once).\n    Output 0: the bit error rate over about the last window_frames frames (0.5 until a frame is found). Output 1: the frames found since the start.\n    Output 2: 1 while the last frame was found one frame period after the one before (locked).\"\"\"\n\n    def __init__(self, payload_syms=960, dmax=16, window_frames=2000):\n        gr.sync_block.__init__(self, name=\"Frame sync + BER\", in_sig=[np.uint8], out_sig=[np.float32, np.float32, np.float32])\n        self.pl = int(payload_syms); self.dmax = int(dmax); self.win = float(window_frames)\n        a = [1, 0, 0, 0, 0, 0]\n        while len(a) < 63:\n            n = len(a) - 6\n            a.append(a[n + 1] ^ a[n])\n        pre = [0, 0]\n        for b in a:\n            pre += [1, 1] if b else [0, 0]\n        self.pre = np.array(pre, dtype=np.uint8)\n        s, pay = 0x7FFF, []\n        for i in range(2 * self.pl):\n            pay.append((s >> 14) & 1)\n            s = ((s << 1) & 0x7FFF) | (((s >> 14) ^ (s >> 13)) & 1)\n        self.pay = np.array(pay, dtype=np.uint8)\n        self.fb = 2 * (64 + self.pl)                       # frame length in bits\n        self.need = 128 + 2 * self.pl                      # a whole frame (preamble + payload) must be in the buffer\n        self.buf = np.zeros(0, dtype=np.uint8); self.base = 0       # absolute bit index of buf[0]\n        self.next_scan = 0                                 # absolute index: nothing before it is searched\n        self.frames = 0; self.m = 0.0; self.n = 0.0; self.ber = 0.5; self.locked_flag = 0.0; self.last_q = None\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        self.buf = np.concatenate([self.buf, x & 1])\n        start = max(self.next_scan - self.base, 0)\n        while len(self.buf) - start >= self.need:\n            last = len(self.buf) - self.need               # last position whose whole frame is present\n            win = np.lib.stride_tricks.sliding_window_view(self.buf[start:last + 128], 128)\n            dist = np.count_nonzero(win != self.pre, axis=1)\n            hit = np.nonzero(dist <= self.dmax)[0]\n            if len(hit) == 0:\n                start = last + 1                           # nothing in this stretch; the rest arrives with the next bits\n                break\n            k = int(hit[0]); k += int(np.argmin(dist[k:k + 4]))\n            q = start + k\n            err = float(np.count_nonzero(self.buf[q + 128:q + self.need] != self.pay))\n            kk = np.exp(-1.0 / self.win)\n            self.m = self.m * kk + err; self.n = self.n * kk + 2 * self.pl\n            self.ber = self.m / self.n\n            self.frames += 1\n            absq = self.base + q\n            self.locked_flag = 1.0 if (self.last_q is not None and abs(absq - self.last_q - self.fb) <= 4) else 0.0\n            self.last_q = absq\n            self.next_scan = absq + self.fb - 16           # the next preamble is one frame later (a margin for a lost or added bit)\n            start = max(self.next_scan - self.base, 0)\n        self.next_scan = self.base + start\n        cut = min(start, len(self.buf))\n        if cut > 0:\n            self.buf = self.buf[cut:]; self.base += cut\n        output_items[0][:] = self.ber; output_items[1][:] = self.frames; output_items[2][:] = self.locked_flag\n        return len(x)\n"
    dmax: '16'
    payload_syms: payload_syms
    window_frames: '2000'
  states: {}
- name: import_firdes
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,4,2
    label1: symbols
    legend: 'False'
    name: '"after the Costas loop"'
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 4,2,4,2
    label1: B210 RX2
    legend: 'False'
    name: '"received spectrum"'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    comment: 0.5 = no frames found; 0 = every payload bit right
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,0,1,2
    label1: BER
    min: '0'
    name: '"payload bit error rate"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.0'
    comment: 937.5 frames per second for 960 payload symbols (3.84 MSPS / 4 / 1024)
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,2,1,2
    label1: frames
    max: '100000000'
    min: '0'
    name: '"frames found"'
    type: float
    update_time: '0.25'
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,4
    label1: lock
    min: '0'
    name: '"frame lock (1 = frames arrive one frame period apart)"'
    type: float
    update_time: '0.25'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    comment: the B210 receiver (RX2 port)
    dev_addr: ''
    dev_args: num_send_frames=128,num_recv_frames=128,send_frame_size=16360,recv_frame_size=16360
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_complex_0, '0']
- [analog_rail_ff_1, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_float_0, '1', analog_rail_ff_1, '0']
- [blocks_float_to_complex_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_number_sink_0, '0']
- [blocks_keep_one_in_n_1, '0', qtgui_number_sink_1, '0']
- [blocks_keep_one_in_n_2, '0', qtgui_number_sink_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '1', blocks_null_sink_0, '0']
- [digital_fll_band_edge_cc_0, '2', blocks_null_sink_1, '0']
- [digital_fll_band_edge_cc_0, '3', blocks_null_sink_2, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', blocks_null_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '2', blocks_null_sink_4, '0']
- [digital_pfb_clock_sync_xxx_0, '3', blocks_null_sink_5, '0']
- [epy_block_0, '0', blocks_keep_one_in_n_0, '0']
- [epy_block_0, '1', blocks_keep_one_in_n_1, '0']
- [epy_block_0, '2', blocks_keep_one_in_n_2, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
